/* $Id: libserdes.c,v 1.2 2017/07/28 07:58:48 harrchan Exp $
 * $Source: /auto/diag/ngd-linux-rep/cvs/ng_diag/dsp_src/src/oakenshield_dsp/ppb/lib/libserdes.c,v $
 *------------------------------------------------------------------
 * libserdes.c
 *
 * Mar 2012, Smita Rane
 *
 * Copyright (c) 2012-2017 by Cisco Systems, Inc.
 * All rights reserved.
 *
 *------------------------------------------------------------------
 */

#include <stdint.h>
#include <stdlib.h>
#include "lsi_sp27xx_reg.h"
#include "libserdes.h"
#include "libgeneric.h"

#include <stdio.h>

/* SR ?? Add this from the Fusion IDE lsi_sp27xx_serdes.h file */
#define LSI_SP27XX_TXDCORE38_TX_XCKSELREG_BM 0x00000010

extern void bsp_debug_printf (const char *fmt, ...);

/* SR end */

#define SERDES_RESET_BITS(addr, o_bit, f_bit)	(*(lsi_sp27xx_register*)(addr) = (uint32_t)(((*(lsi_sp27xx_register*)(addr)) & ~f_bit) | o_bit))
#define ALL_CH	9 //Global all-channel setting

/* CMU10 register */
#define SRIO_SERDES_CMU10_SPLLA_SELI 0x1
#define SRIO_SERDES_CMU10_SPLLB_SELI 0x1
#define SRIO_SERDES_CMU10_FPLLA_SELI 0x5
#define SRIO_SERDES_CMU10_FPLLB_SELI 0x5

#define GIGE_SERDES_CMU10_SPLLA_SELI 0x1
#define GIGE_SERDES_CMU10_SPLLB_SELI 0x1
#define GIGE_SERDES_CMU10_FPLLA_SELI 0x5
#define GIGE_SERDES_CMU10_FPLLB_SELI 0x5

/* CMU9 register */
#define SRIO_SERDES_CMU9_SPLL_SLCTRL 0x1
#define SRIO_SERDES_CMU9_FPLL_SLCTRL_A 0x2
#define SRIO_SERDES_CMU9_FPLL_SLCTRL_B 0x4

#define GIGE_SERDES_CMU9_SPLL_SLCTRL 0x1
#define GIGE_SERDES_CMU9_FPLL_SLCTRL_A 0x2
#define GIGE_SERDES_CMU9_FPLL_SLCTRL_B 0x4

/* CMU7 register */
#define SRIO_SERDES_CMU7_SPLL_BGSV 0x1
#define SRIO_SERDES_CMU7_FPLL_BGSV 0x4
#define SRIO_SERDES_CMU7_SPLL_SPAREIN	0x1
#define SRIO_SERDES_CMU7_FPLL_SPAREIN	0x0

#define GIGE_SERDES_CMU7_SPLL_BGSV 0x1
#define GIGE_SERDES_CMU7_FPLL_BGSV 0x4
#define GIGE_SERDES_CMU7_SPLL_SPAREIN	0x1
#define GIGE_SERDES_CMU7_FPLL_SPAREIN	0x0

/* CMU6 register */
#define SRIO_SERDES_CMU6_SPLL_CMUVR 0x1
#define SRIO_SERDES_CMU6_FPLL_CMUVR 0x4
#define SRIO_SERDES_CMU6_SPLL_BGTC 0x1
#define SRIO_SERDES_CMU6_FPLL_BGTC 0x5

#define GIGE_SERDES_CMU6_SPLL_CMUVR 0x1
#define GIGE_SERDES_CMU6_FPLL_CMUVR 0x4
#define GIGE_SERDES_CMU6_SPLL_BGTC 0x1
#define GIGE_SERDES_CMU6_FPLL_BGTC 0x5

/* CMU5 register */
#define SRIO_SERDES_CMU5_SPLL_ICP 0x1
#define SRIO_SERDES_CMU5_FPLL_ICP_A 0x4
#define SRIO_SERDES_CMU5_FPLL_ICP_B	0x0
#define	SRIO_SERDES_CMU5_SPLL_RBCAP	0x1
#define SRIO_SERDES_CMU5_FPLL_RBCAP	0x0
#define SRIO_SERDES_CMU5_SPLL_RES	0x1
#define SRIO_SERDES_CMU5_FPLL_RES	0x0

#define GIGE_SERDES_CMU5_SPLL_ICP 0x1
#define GIGE_SERDES_CMU5_FPLL_ICP_A 0x4
#define GIGE_SERDES_CMU5_FPLL_ICP_B	0x0
#define	GIGE_SERDES_CMU5_SPLL_RBCAP	0x1
#define GIGE_SERDES_CMU5_FPLL_RBCAP	0x0
#define GIGE_SERDES_CMU5_SPLL_RES	0x1
#define GIGE_SERDES_CMU5_FPLL_RES	0x0

/* TX0/1 register control 50 */
#define SRIO_SERDES_TX50_C0O	0x1
#define SRIO_SERDES_TX50_C0F	0x0
#define SRIO_SERDES_TX50_CP1O	0x1
#define SRIO_SERDES_TX50_CP1F	0x0

#define GIGE_SERDES_TX50_C0O	0x1
#define GIGE_SERDES_TX50_C0F	0x0
#define GIGE_SERDES_TX50_CP1O	0x1
#define GIGE_SERDES_TX50_CP1F	0x0

/* RX0/1 register control 1 */
#define SRIO_SERDES_RX1_LOSVREFO	0x1
#define SRIO_SERDES_RX1_LOSVREFF	0x9

#define GIGE_SERDES_RX1_LOSVREFO	0x1
#define GIGE_SERDES_RX1_LOSVREFF	0x9

/* RX0/1 register control 3 */
#define SRIO_SERDES_RX3_FETRIMENO	0x1
#define SRIO_SERDES_RX3_FETRIMENF	0x0

#define GIGE_SERDES_RX3_FETRIMENO	0x1
#define GIGE_SERDES_RX3_FETRIMENF	0x0

/* CMUCNTRL0_SPLL_DUALMODE select force bits */
#define SRIO_SERDES_CMUCNTRL0_SPLL_DUALMODE	0x1

#define GIGE_SERDES_CMUCNTRL0_SPLL_DUALMODE	0x1

/* PLLB select force bits */
#define SRIO_SERDES_CMUCNTRL0_SPLL_MODESELB	0x1

#define GIGE_SERDES_CMUCNTRL0_SPLL_MODESELB	0x1

/* Each time this function is called with a valid speed value, a reset is performed on the whole GigE SerDes
 * block despite the value of the "channel" parameter. If we intend to use a single channel (either MAC0
 * or MAC1), the other unused channel will be powered down with the intention to save power.
 */
/* This function assumes that a 125 MHz SerDes reference clock is used for the GigE SerDes */
int32_t sp_GigeSerdesInit(serdesRateCfg_t speed, uint8_t channel, uint8_t ckiInMHz)
{
	uint32_t DRF;
	uint32_t PLLA_MDIV4 = 0;
	uint32_t MODESELB;
	uint32_t DUALMODE;

	uint32_t fail = 0;

	uint32_t timeout = sp_timeoutValUsing32bitRTC(1000, ckiInMHz); /* >= 1 ms */

	/* If the channel parameter doesn't represent any of the SerDes channels, return an error */
	if ((channel != CHAN(0)) && (channel != CHAN(1)) && (channel != (CHAN(0)|CHAN(1))))
		return(ERROR);

	if (speed == GBAUD_3_125) //3.125 GBAUD
	{
		DRF = 0x1;
		MODESELB = 0x1;
		DUALMODE = 0x1;
	}
	else if (speed == GBAUD_2_5) //2.5 GBAUD
	{
		DRF = 0x1;
		PLLA_MDIV4 = 0x1;
		MODESELB = 0x0;
		DUALMODE = 0x0;
	}
	else if (speed == GBAUD_1_25) //1.25 GBAUD
	{
		DRF = 0x2;
		PLLA_MDIV4 = 0x2;
		MODESELB = 0x0;
		DUALMODE = 0x0;
	}
	/* If the interface we are trying to power up is already powered down, we need to ignore the full re-initialization routine
	 * and use a simplified one for the powered down port.
	 */
	else if (speed == ENABLE_SERDES)
	{
		if (channel == CHAN(0))
		{
			/* Assert PLL_CKDIS, RX_RESET, and TX_RESET */
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

			/* If the TX PD override bit is set, and if the TX PD force bit is set, power the channel back up.
			 * Otherwise, if the channel is not powered down or is not initialized, return(ERROR) because
			 * the requested functionality was not completed as expected.
			 */
			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0) & LSI_SP27XX_TXDCORE47_TX_PDO_BM) >> LSI_SP27XX_TXDCORE47_TX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0) & LSI_SP27XX_TXDCORE47_TX_PDF_BM) >> LSI_SP27XX_TXDCORE47_TX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_PDO_BM, LSI_SP27XX_TXDCORE47_TX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			/* If the RX PD override bit is set, and if the RX PD force bit is set, power the channel back up.
			 * Otherwise, if the channel is not powered down or is not initialized, return(ERROR) because
			 * the requested functionality was not completed as expected.
			 */
			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0) & LSI_SP27XX_RXDCORE0_RX_PDO_BM) >> LSI_SP27XX_RXDCORE0_RX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0) & LSI_SP27XX_RXDCORE0_RX_PDF_BM) >> LSI_SP27XX_RXDCORE0_RX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_PDO_BM, LSI_SP27XX_RXDCORE0_RX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			/* Allow time for the channel to settle after releasing PD (~1 ms) */
			//if (sp_delayUsingRTC(1000,ckiInMHz) != 0)
			//	return(ERROR);
 lsi_mg_delay(0xFFFFF);

			/* Once the channel is powered back up, we need to synchronously restart the high speed transmitters on the whole SerDes interface */
			/* Deassert RX_RESET, TX_RESET, and PLL_CKDIS */
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM, LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

			if (fail)
				return(ERROR);
			else
				return(SUCCESS);
		}
		else if (channel == CHAN(1))
		{
			/* Assert PLL_CKDIS, RX_RESET, and TX_RESET */
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

			/* If the TX PD override bit is set, and if the TX PD force bit is set, power the channel back up.
			 * Otherwise, if the channel is not powered down or is not initialized, return(ERROR) because
			 * the requested functionality was not completed as expected.
			 */
			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1) & LSI_SP27XX_TXDCORE47_TX_PDO_BM) >> LSI_SP27XX_TXDCORE47_TX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1) & LSI_SP27XX_TXDCORE47_TX_PDF_BM) >> LSI_SP27XX_TXDCORE47_TX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_PDO_BM, LSI_SP27XX_TXDCORE47_TX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			/* If the RX PD override bit is set, and if the RX PD force bit is set, power the channel back up.
			 * Otherwise, if the channel is not powered down or is not initialized, return(ERROR) because
			 * the requested functionality was not completed as expected.
			 */
			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1) & LSI_SP27XX_RXDCORE0_RX_PDO_BM) >> LSI_SP27XX_RXDCORE0_RX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1) & LSI_SP27XX_RXDCORE0_RX_PDF_BM) >> LSI_SP27XX_RXDCORE0_RX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_PDO_BM, LSI_SP27XX_RXDCORE0_RX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			/* Allow time for the channel to settle after releasing PD (~1 ms) */
			//if (sp_delayUsingRTC(1000,ckiInMHz) != 0)
			//	return(ERROR);
 lsi_mg_delay(0xFFFFF);

			/* Once the channel is powered back up, we need to synchronously restart the high speed transmitters on the whole SerDes interface */
			/* Deassert RX_RESET, TX_RESET, and PLL_CKDIS */
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM, LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

			if (fail)
				return(ERROR);
			else
				return(SUCCESS);
		}
		else //if channel is CHAN(0)|CHAN(1)
		{
			/* Assert PLL_CKDIS, RX_RESET, and TX_RESET */
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

			/* If the TX PD override bit is set, and if the TX PD force bit is set, power the channel back up.
			 * Otherwise, if the channel is not powered down or is not initialized, return(ERROR) because
			 * the requested functionality was not completed as expected.
			 */
			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0) & LSI_SP27XX_TXDCORE47_TX_PDO_BM) >> LSI_SP27XX_TXDCORE47_TX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0) & LSI_SP27XX_TXDCORE47_TX_PDF_BM) >> LSI_SP27XX_TXDCORE47_TX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_PDO_BM, LSI_SP27XX_TXDCORE47_TX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1) & LSI_SP27XX_TXDCORE47_TX_PDO_BM) >> LSI_SP27XX_TXDCORE47_TX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1) & LSI_SP27XX_TXDCORE47_TX_PDF_BM) >> LSI_SP27XX_TXDCORE47_TX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_PDO_BM, LSI_SP27XX_TXDCORE47_TX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			/* If the RX PD override bit is set, and if the RX PD force bit is set, power the channel back up.
			 * Otherwise, if the channel is not powered down or is not initialized, return(ERROR) because
			 * the requested functionality was not completed as expected.
			 */
			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0) & LSI_SP27XX_RXDCORE0_RX_PDO_BM) >> LSI_SP27XX_RXDCORE0_RX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0) & LSI_SP27XX_RXDCORE0_RX_PDF_BM) >> LSI_SP27XX_RXDCORE0_RX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_PDO_BM, LSI_SP27XX_RXDCORE0_RX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1) & LSI_SP27XX_RXDCORE0_RX_PDO_BM) >> LSI_SP27XX_RXDCORE0_RX_PDO_BO)
			{
				if ((*(volatile uint32_t*)LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1) & LSI_SP27XX_RXDCORE0_RX_PDF_BM) >> LSI_SP27XX_RXDCORE0_RX_PDF_BO)
				{
					SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_PDO_BM, LSI_SP27XX_RXDCORE0_RX_PDF_BM);
				}
				else
					fail = 1;
			}
			else
				fail = 1;

			/* Allow time for the channel to settle after releasing PD (~1 ms) */
			//if (sp_delayUsingRTC(1000,ckiInMHz) != 0)
			//	return(ERROR);
 lsi_mg_delay(0xFFFFF);

			/* Once the channels are powered back up, we need to synchronously restart the high speed transmitters on the whole SerDes interface */
			/* Deassert RX_RESET, TX_RESET, and PLL_CKDIS */
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
			SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM, LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

			if (fail)
				return(ERROR);
			else
				return(SUCCESS);
		}
	}
	else if (speed == DISABLE_SERDES)
	{
		/* Power down the transmitter(s) and receiver(s) */
		if ((channel & CHAN(0)) == CHAN(0))
		{
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																	|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																	|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
		}

		if ((channel & CHAN(1)) == CHAN(1))
		{
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																	|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
			REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																	|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
		}

		return(SUCCESS);
	}
	else /* The parameter is incorrect */
		return(ERROR);

	/* Put the SerDes into configuration mode */
	REG32_SET_BITS(LSI_SP27XX_CAR_GIGE_SERDES_UPDATE_RA, LSI_SP27XX_GIGE_SERDES_UPDATE_GIGE_SERDES_UPDATE_BM);

	/* Perform a master software reset of the SerDes interface if "initializing" a data rate (and not trying to power up a down channel) */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_CMUSWRESET_BM);
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_CMUSWRESET_BM);

	/* Even though SERDES_UPDATE touches this, disable internal phase transfer fifo until all internal clocks are available */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE49_RA(0),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE49_RA(1),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	/* Disable the DUALMODE bit (if not already disabled), and then set it based on desired serial rate */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_DUALMODE_BM|LSI_SP27XX_CMUCNTRL0_FPLL_DUALMODE_BM);

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, (DUALMODE<<LSI_SP27XX_CMUCNTRL0_FPLL_DUALMODE_BO)\
														|(GIGE_SERDES_CMUCNTRL0_SPLL_DUALMODE<<LSI_SP27XX_CMUCNTRL0_SPLL_DUALMODE_BO));

	/* Deselect PLLB (if not already deselected), and then set it based on desired serial rate */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_FPLL_MODESELB_BM|LSI_SP27XX_CMUCNTRL0_SPLL_MODESELB_BM);

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, (MODESELB<<LSI_SP27XX_CMUCNTRL0_FPLL_MODESELB_BO)\
															|(GIGE_SERDES_CMUCNTRL0_SPLL_MODESELB<<LSI_SP27XX_CMUCNTRL0_SPLL_MODESELB_BO));

	/* CMU10: register SPLLA_SELI=b1, FPLLA_SELI[2:0]=b110, SPLLB_SELI=b1, FPLLB_SELI[2:0]=b110 */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL10_RA, LSI_SP27XX_CMUCNTRL10_SPLLA_SELI_BM|LSI_SP27XX_CMUCNTRL10_FPLLA_SELI_BM\
														|LSI_SP27XX_CMUCNTRL10_SPLLB_SELI_BM|LSI_SP27XX_CMUCNTRL10_FPLLB_SELI_BM);

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL10_RA, (GIGE_SERDES_CMU10_SPLLA_SELI<<LSI_SP27XX_CMUCNTRL10_SPLLA_SELI_BO)\
														|(GIGE_SERDES_CMU10_FPLLA_SELI<<LSI_SP27XX_CMUCNTRL10_FPLLA_SELI_BO)\
														|(GIGE_SERDES_CMU10_SPLLB_SELI<<LSI_SP27XX_CMUCNTRL10_SPLLB_SELI_BO)\
														|(GIGE_SERDES_CMU10_FPLLB_SELI<<LSI_SP27XX_CMUCNTRL10_FPLLB_SELI_BO));

	/* CMU9 register SPLL_SLCTRL=b1, FPLL_SLCTRL[2:0]=variable */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL9_RA, LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BM|LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BM);

	if (MODESELB == 0x0)
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL9_RA, (GIGE_SERDES_CMU9_SPLL_SLCTRL<<LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BO)\
														   |(GIGE_SERDES_CMU9_FPLL_SLCTRL_A<<LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BO));
	else
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL9_RA, (GIGE_SERDES_CMU9_SPLL_SLCTRL<<LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BO)\
														   |(GIGE_SERDES_CMU9_FPLL_SLCTRL_B<<LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BO));

	/*CMU7 register SPLL_BGSV=b1, FPLL_BGSV[2:0]=b100, SPLL_SPAREIN=b1, FPLL_SPAREIN=b0000 */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL7_RA, LSI_SP27XX_CMUCNTRL7_SPLL_BGSV_BM|LSI_SP27XX_CMUCNTRL7_FPLL_BGSV_BM\
														  |LSI_SP27XX_CMUCNTRL7_SPLL_SPAREIN_BM|LSI_SP27XX_CMUCNTRL7_FPLL_SPAREIN_BM);

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL7_RA, (GIGE_SERDES_CMU7_SPLL_BGSV<<LSI_SP27XX_CMUCNTRL7_SPLL_BGSV_BO)\
													   |(GIGE_SERDES_CMU7_FPLL_BGSV<<LSI_SP27XX_CMUCNTRL7_FPLL_BGSV_BO)\
													   |(GIGE_SERDES_CMU7_SPLL_SPAREIN<<LSI_SP27XX_CMUCNTRL7_SPLL_SPAREIN_BO)\
													   |(GIGE_SERDES_CMU7_FPLL_SPAREIN<<LSI_SP27XX_CMUCNTRL7_FPLL_SPAREIN_BO));

	/*CMU6 register SPLL_CMUVR=b1, FPLL_CMUVR[2:0]=b100, SPLL_BGTC=b1, FPLL_BGTC=b101 */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL6_RA, LSI_SP27XX_CMUCNTRL6_SPLL_CMUVR_BM|LSI_SP27XX_CMUCNTRL6_FPLL_CMUVR_BM\
														|LSI_SP27XX_CMUCNTRL6_SPLL_BGTC_BM|LSI_SP27XX_CMUCNTRL6_FPLL_BGTC_BM);

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL6_RA, (GIGE_SERDES_CMU6_SPLL_CMUVR<<LSI_SP27XX_CMUCNTRL6_SPLL_CMUVR_BO)\
														|(GIGE_SERDES_CMU6_FPLL_CMUVR<<LSI_SP27XX_CMUCNTRL6_FPLL_CMUVR_BO)\
														|(GIGE_SERDES_CMU6_SPLL_BGTC<<LSI_SP27XX_CMUCNTRL6_SPLL_BGTC_BO)\
														|(GIGE_SERDES_CMU6_FPLL_BGTC<<LSI_SP27XX_CMUCNTRL6_FPLL_BGTC_BO));

	/*CMU5 register SPLL_ICP=b1, FPLL_ICP[3:0]=variable, SPLL_RBCAP=b1, FPLL_RBCAP[1:0]=b00 */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL5_RA, LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BM|LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BM\
														|LSI_SP27XX_CMUCNTRL5_SPLL_RES_BM|LSI_SP27XX_CMUCNTRL5_FPLL_RES_BM\
														|LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BM|LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BM);

	if (MODESELB == 0x0)
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL5_RA, (GIGE_SERDES_CMU5_SPLL_ICP<<LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BO)\
														   |(GIGE_SERDES_CMU5_FPLL_ICP_A<<LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BO)\
														   |(GIGE_SERDES_CMU5_SPLL_RES<<LSI_SP27XX_CMUCNTRL5_SPLL_RES_BO)\
														   |(GIGE_SERDES_CMU5_FPLL_RES<<LSI_SP27XX_CMUCNTRL5_FPLL_RES_BO)\
														   |(GIGE_SERDES_CMU5_SPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BO)\
														   |(GIGE_SERDES_CMU5_FPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BO));
	else
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL5_RA, (GIGE_SERDES_CMU5_SPLL_ICP<<LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BO)\
														   |(GIGE_SERDES_CMU5_FPLL_ICP_B<<LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BO)\
														   |(GIGE_SERDES_CMU5_SPLL_RES<<LSI_SP27XX_CMUCNTRL5_SPLL_RES_BO)\
														   |(GIGE_SERDES_CMU5_FPLL_RES<<LSI_SP27XX_CMUCNTRL5_FPLL_RES_BO)\
														   |(GIGE_SERDES_CMU5_SPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BO)\
														   |(GIGE_SERDES_CMU5_FPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BO));

	/* Set the sub-dividers based on the desired channel operating rate  */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL2_RA, LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV3_BM|LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV3_BM\
														|LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV4_BM|LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV4_BM);

	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL4_RA, LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV3_BM|LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV3_BM\
														|LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV4_BM|LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV4_BM);

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL2_RA, (0x1<<LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV3_BO)\
														|(0x3<<LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV3_BO));

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL4_RA, (0x1<<LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV3_BO)\
														|(0x4<<LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV3_BO));

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL2_RA, (0x1<<LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV4_BO)\
														|(PLLA_MDIV4<<LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV4_BO));

	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL4_RA, (0x1<<LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV4_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV4_BO));

	/*TX 0/1/2/3 register control 50 TX_C0O=b1, TX_C0F[3:0] = b0000, TX_CP1O = b1, TX_CP1F[3:0] = b0000  */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE50_RA(0),
						(LSI_SP27XX_TXDCORE50_TX_C0O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
						(LSI_SP27XX_TXDCORE50_TX_C0F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE50_RA(0), (GIGE_SERDES_TX50_C0F<<LSI_SP27XX_TXDCORE50_TX_C0F_BO)\
														|(GIGE_SERDES_TX50_C0O<<LSI_SP27XX_TXDCORE50_TX_C0O_BO)\
														|(GIGE_SERDES_TX50_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO)\
														|(GIGE_SERDES_TX50_CP1O<<LSI_SP27XX_TXDCORE50_TX_CP1O_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE50_RA(1),
						(LSI_SP27XX_TXDCORE50_TX_C0O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
						(LSI_SP27XX_TXDCORE50_TX_C0F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE50_RA(1), (GIGE_SERDES_TX50_C0F<<LSI_SP27XX_TXDCORE50_TX_C0F_BO)\
														|(GIGE_SERDES_TX50_C0O<<LSI_SP27XX_TXDCORE50_TX_C0O_BO)\
														|(GIGE_SERDES_TX50_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO)\
														|(GIGE_SERDES_TX50_CP1O<<LSI_SP27XX_TXDCORE50_TX_CP1O_BO));

	/*RX 0/1/2/3 register control 1 RX_LOSVREFO = b1, RX_LOSVREFF[4:0] = b01001 */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_RXDCORE1_RA(0),
						LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM,
						LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM);
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE1_RA(0), (GIGE_SERDES_RX1_LOSVREFO<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)\
															|(GIGE_SERDES_RX1_LOSVREFF<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_RXDCORE1_RA(1),
						LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM,
						LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM);
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE1_RA(1), (GIGE_SERDES_RX1_LOSVREFO<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)\
															|(GIGE_SERDES_RX1_LOSVREFF<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	/*RX 0 register control 3 RX_FETRIMENO = b1, RX_FETRIMENF = b0 */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_RXDCORE3_RA(0),
						LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM,
						LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM);
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE3_RA(0), (GIGE_SERDES_RX3_FETRIMENO<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
															|(GIGE_SERDES_RX3_FETRIMENF<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_RXDCORE3_RA(1),
						LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM,
						LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM);
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE3_RA(1), (GIGE_SERDES_RX3_FETRIMENO<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
															|(GIGE_SERDES_RX3_FETRIMENF<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO));


    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_CAR_SERDES_TRIMDONE_RA, LSI_SP27XX_SERDES_TRIMDONE_SERDES_TRIMDONE_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* SPLL CKDIS=1 & FPLL CKDIS=1 */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);
	/* FPLL_CAL =0 & SPLL_CAL =0 */
	REG32_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CAL_BM);
	/* FPLL_CAL =0 & SPLL_CAL =1 */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM);

	/* TX_RESETO =1, TX_RESETF=1*/
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

	/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0),
						LSI_SP27XX_TXDCORE47_TX_DRO_BM,
						LSI_SP27XX_TXDCORE47_TX_DRF_BM);
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1),
						LSI_SP27XX_TXDCORE47_TX_DRO_BM,
						LSI_SP27XX_TXDCORE47_TX_DRF_BM);
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/* RX_RESETO =1, RX_RESETF=1*/
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);

	/* RX_DR0=1, RX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0),
						LSI_SP27XX_RXDCORE0_RX_DRO_BM,
						LSI_SP27XX_RXDCORE0_RX_DRF_BM);
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_DRO_BM|(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO)));

	/* RX_DR0=1, RX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1),
						LSI_SP27XX_RXDCORE0_RX_DRO_BM,
						LSI_SP27XX_RXDCORE0_RX_DRF_BM);
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_DRO_BM|(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO)));

	/* FPLL_CAL = 1 & SPLL_CAL = 1 */
	REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CAL_BM);

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_GIGE_SERDES_CMUSTATUS31_RA, LSI_SP27XX_CMUSTATUS31_PLL_READY_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* reset TX RESETF */
	SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);

	/* reset RX RESETF */
	SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);

	 /* program  FPLL_CKDIS = 0 */
	SERDES_RESET_BITS(LSI_SP27XX_GIGE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM, LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_GIGE_SERDES_CMUSTATUS31_RA, LSI_SP27XX_CMUSTATUS31_PLL_TXREADY_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_GIGE_SERDES_RXDCORE11_RA(0), LSI_SP27XX_RXDCORE11_RX_TRIMDONE_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_GIGE_SERDES_RXDCORE11_RA(1), LSI_SP27XX_RXDCORE11_RX_TRIMDONE_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* Enable the internal phase transfer fifo */
	REG32_SET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE49_RA(0),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	REG32_SET_BITS(	LSI_SP27XX_GIGE_SERDES_TXDCORE49_RA(1),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	/* If the "channel" parameter signifies a single channel, power down the channel which is not in use */
	if (channel == CHAN(0)) // if we are only initializing MAC0, power down MAC1
	{
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(1), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(1), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
	}

	if (channel == CHAN(1)) // if we are only initializing MAC1, power down MAC0
	{
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_TXDCORE47_RA(0), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_GIGE_SERDES_RXDCORE0_RA(0), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
	}

	/* Put the SerDes into normal mode */
	REG32_RESET_BITS(LSI_SP27XX_CAR_GIGE_SERDES_UPDATE_RA, LSI_SP27XX_GIGE_SERDES_UPDATE_GIGE_SERDES_UPDATE_BM);

	return(SUCCESS);
}

/* Each time this function is called with a valid speed value, a reset is performed on the whole sRIO SerDes
 * block despite the value of the "lane_mode" parameter. If we intend to use anything but the 1x4 mode, the
 * unused channels will be powered down.  Please be aware of the lane mode before calling this function,
 * or call sp_sRIO_SetLaneMode() before calling this SerDes initialization function.
 */
/* This function assumes that a 125 MHz SerDes reference clock is used for the sRIO SerDes */
int32_t
sp_SrioSerdesInit(serdesRateCfg_t speed, uint8_t lane_mode, uint8_t ckiInMHz)
{
	uint32_t DRF;
	uint32_t PLLA_MDIV4 = 0;
	uint32_t MODESELB;
	uint32_t DUALMODE;

	uint32_t timeout = sp_timeoutValUsing32bitRTC(1000, ckiInMHz); /* >= 1 ms */

	/* If the lane_mode parameter is not supported, return an error */
	if (speed != DISABLE_SERDES)
	{
		if ((lane_mode != sRIO_1x4_mode) && (lane_mode != sRIO_2x1_mode) && (lane_mode != sRIO0_x1_mode) && (lane_mode != sRIO1_x1_mode))
			return(ERROR);
	}

	if (speed == GBAUD_3_125) //3.125 GBAUD
	{
		DRF = 0x1;
		MODESELB = 0x1;
		DUALMODE = 0x1;
	}
	else if (speed == GBAUD_2_5) //2.5 GBAUD
	{
		DRF = 0x1;
		PLLA_MDIV4 = 0x1;
		MODESELB = 0x0;
		DUALMODE = 0x0;
	}
	else if (speed == GBAUD_1_25) //1.25 GBAUD
	{
		DRF = 0x2;
		PLLA_MDIV4 = 0x2;
		MODESELB = 0x0;
		DUALMODE = 0x0;
	}
	else if (speed == DISABLE_SERDES)
	{
		/* Power down ALL transmitters and receivers despite the lane_mode parameter passed in */
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(0), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(0), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));

		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(1), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(1), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));

		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(2), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(2), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));

		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(3), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(3), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));

		return(SUCCESS);
	}
	else /* Wrong parameter passed in */
		return(ERROR);

	/* Put the SerDes into configuration mode */
	REG32_SET_BITS(LSI_SP27XX_CAR_SRIO_SERDES_UPDATE_RA, LSI_SP27XX_SRIO_SERDES_UPDATE_SRIO_SERDES_UPDATE_BM);

	/* Perform a master software reset of the SerDes interface if "initializing" a data rate */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_CMUSWRESET_BM);
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_CMUSWRESET_BM);

	/* Even though SERDES_UPDATE touches this, disable internal phase transfer fifo until all internal clocks are available */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(0),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(1),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(2),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(3),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	/* Disable the DUALMODE bit (if not already disabled), and then set it based on desired serial rate */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_DUALMODE_BM|LSI_SP27XX_CMUCNTRL0_FPLL_DUALMODE_BM);

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, (DUALMODE<<LSI_SP27XX_CMUCNTRL0_FPLL_DUALMODE_BO)\
														|(SRIO_SERDES_CMUCNTRL0_SPLL_DUALMODE<<LSI_SP27XX_CMUCNTRL0_SPLL_DUALMODE_BO));

	/* Deselect PLLB (if not alrady deselected), and then set it based on desired serial rate */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_FPLL_MODESELB_BM|LSI_SP27XX_CMUCNTRL0_SPLL_MODESELB_BM);

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, (MODESELB<<LSI_SP27XX_CMUCNTRL0_FPLL_MODESELB_BO)\
															|(SRIO_SERDES_CMUCNTRL0_SPLL_MODESELB<<LSI_SP27XX_CMUCNTRL0_SPLL_MODESELB_BO));

	/* CMU10: register SPLLA_SELI=b1, FPLLA_SELI[2:0]=b110, SPLLB_SELI=b1, FPLLB_SELI[2:0]=b110 */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL10_RA, LSI_SP27XX_CMUCNTRL10_SPLLA_SELI_BM|LSI_SP27XX_CMUCNTRL10_FPLLA_SELI_BM\
														|LSI_SP27XX_CMUCNTRL10_SPLLB_SELI_BM|LSI_SP27XX_CMUCNTRL10_FPLLB_SELI_BM);

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL10_RA, (SRIO_SERDES_CMU10_SPLLA_SELI<<LSI_SP27XX_CMUCNTRL10_SPLLA_SELI_BO)\
														|(SRIO_SERDES_CMU10_FPLLA_SELI<<LSI_SP27XX_CMUCNTRL10_FPLLA_SELI_BO)\
														|(SRIO_SERDES_CMU10_SPLLB_SELI<<LSI_SP27XX_CMUCNTRL10_SPLLB_SELI_BO)\
														|(SRIO_SERDES_CMU10_FPLLB_SELI<<LSI_SP27XX_CMUCNTRL10_FPLLB_SELI_BO));

	/* CMU9 register SPLL_SLCTRL=b1, FPLL_SLCTRL[2:0]=variable */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL9_RA, LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BM|LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BM);

	if (MODESELB == 0x0)
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL9_RA, (SRIO_SERDES_CMU9_SPLL_SLCTRL<<LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BO)\
														   |(SRIO_SERDES_CMU9_FPLL_SLCTRL_A<<LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BO));
	else
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL9_RA, (SRIO_SERDES_CMU9_SPLL_SLCTRL<<LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BO)\
														   |(SRIO_SERDES_CMU9_FPLL_SLCTRL_B<<LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BO));

	/*CMU7 register SPLL_BGSV=b1, FPLL_BGSV[2:0]=b100, SPLL_SPAREIN=b1, FPLL_SPAREIN=b0000 */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL7_RA, LSI_SP27XX_CMUCNTRL7_SPLL_BGSV_BM|LSI_SP27XX_CMUCNTRL7_FPLL_BGSV_BM\
														  |LSI_SP27XX_CMUCNTRL7_SPLL_SPAREIN_BM|LSI_SP27XX_CMUCNTRL7_FPLL_SPAREIN_BM);

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL7_RA, (SRIO_SERDES_CMU7_SPLL_BGSV<<LSI_SP27XX_CMUCNTRL7_SPLL_BGSV_BO)\
													   |(SRIO_SERDES_CMU7_FPLL_BGSV<<LSI_SP27XX_CMUCNTRL7_FPLL_BGSV_BO)\
													   |(SRIO_SERDES_CMU7_SPLL_SPAREIN<<LSI_SP27XX_CMUCNTRL7_SPLL_SPAREIN_BO)\
													   |(SRIO_SERDES_CMU7_FPLL_SPAREIN<<LSI_SP27XX_CMUCNTRL7_FPLL_SPAREIN_BO));

	/*CMU6 register SPLL_CMUVR=b1, FPLL_CMUVR[2:0]=b100, SPLL_BGTC=b1, FPLL_BGTC=b101 */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL6_RA, LSI_SP27XX_CMUCNTRL6_SPLL_CMUVR_BM|LSI_SP27XX_CMUCNTRL6_FPLL_CMUVR_BM\
														|LSI_SP27XX_CMUCNTRL6_SPLL_BGTC_BM|LSI_SP27XX_CMUCNTRL6_FPLL_BGTC_BM);

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL6_RA, (SRIO_SERDES_CMU6_SPLL_CMUVR<<LSI_SP27XX_CMUCNTRL6_SPLL_CMUVR_BO)\
														|(SRIO_SERDES_CMU6_FPLL_CMUVR<<LSI_SP27XX_CMUCNTRL6_FPLL_CMUVR_BO)\
														|(SRIO_SERDES_CMU6_SPLL_BGTC<<LSI_SP27XX_CMUCNTRL6_SPLL_BGTC_BO)\
														|(SRIO_SERDES_CMU6_FPLL_BGTC<<LSI_SP27XX_CMUCNTRL6_FPLL_BGTC_BO));

	/*CMU5 register SPLL_ICP=b1, FPLL_ICP[3:0]=variable, SPLL_RBCAP=b1, FPLL_RBCAP[1:0]=b00 */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL5_RA, LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BM|LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BM\
														|LSI_SP27XX_CMUCNTRL5_SPLL_RES_BM|LSI_SP27XX_CMUCNTRL5_FPLL_RES_BM\
														|LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BM|LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BM);

	if (MODESELB == 0x0)
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL5_RA, (SRIO_SERDES_CMU5_SPLL_ICP<<LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BO)\
														   |(SRIO_SERDES_CMU5_FPLL_ICP_A<<LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BO)\
														   |(SRIO_SERDES_CMU5_SPLL_RES<<LSI_SP27XX_CMUCNTRL5_SPLL_RES_BO)\
														   |(SRIO_SERDES_CMU5_FPLL_RES<<LSI_SP27XX_CMUCNTRL5_FPLL_RES_BO)\
														   |(SRIO_SERDES_CMU5_SPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BO)\
														   |(SRIO_SERDES_CMU5_FPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BO));
	else
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL5_RA, (SRIO_SERDES_CMU5_SPLL_ICP<<LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BO)\
														   |(SRIO_SERDES_CMU5_FPLL_ICP_B<<LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BO)\
														   |(SRIO_SERDES_CMU5_SPLL_RES<<LSI_SP27XX_CMUCNTRL5_SPLL_RES_BO)\
														   |(SRIO_SERDES_CMU5_FPLL_RES<<LSI_SP27XX_CMUCNTRL5_FPLL_RES_BO)\
														   |(SRIO_SERDES_CMU5_SPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BO)\
														   |(SRIO_SERDES_CMU5_FPLL_RBCAP<<LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BO));

	/* Set the sub-dividers based on the desired channel operating rate  */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL2_RA, LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV3_BM|LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV3_BM\
														|LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV4_BM|LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV4_BM);

	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL4_RA, LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV3_BM|LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV3_BM\
														|LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV4_BM|LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV4_BM);

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL2_RA, (0x1<<LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV3_BO)\
														|(0x3<<LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV3_BO));

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL4_RA, (0x1<<LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV3_BO)\
														|(0x4<<LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV3_BO));

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL2_RA, (0x1<<LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV4_BO)\
														|(PLLA_MDIV4<<LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV4_BO));

	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL4_RA, (0x1<<LSI_SP27XX_CMUCNTRL4_SPLLB_MDIV4_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL4_FPLLB_MDIV4_BO));

	/*TX 0/1/2/3 register control 50 TX_C0O=b1, TX_C0F[3:0] = b0000, TX_CP1O = b1, TX_CP1F[3:0] = b0000  */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(0),
						(LSI_SP27XX_TXDCORE50_TX_C0O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
						(LSI_SP27XX_TXDCORE50_TX_C0F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(0), (SRIO_SERDES_TX50_C0F<<LSI_SP27XX_TXDCORE50_TX_C0F_BO)\
														|(SRIO_SERDES_TX50_C0O<<LSI_SP27XX_TXDCORE50_TX_C0O_BO)\
														|(SRIO_SERDES_TX50_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO)\
														|(SRIO_SERDES_TX50_CP1O<<LSI_SP27XX_TXDCORE50_TX_CP1O_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(1),
						(LSI_SP27XX_TXDCORE50_TX_C0O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
						(LSI_SP27XX_TXDCORE50_TX_C0F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(1), (SRIO_SERDES_TX50_C0F<<LSI_SP27XX_TXDCORE50_TX_C0F_BO)\
														|(SRIO_SERDES_TX50_C0O<<LSI_SP27XX_TXDCORE50_TX_C0O_BO)\
														|(SRIO_SERDES_TX50_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO)\
														|(SRIO_SERDES_TX50_CP1O<<LSI_SP27XX_TXDCORE50_TX_CP1O_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(2),
						(LSI_SP27XX_TXDCORE50_TX_C0O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
						(LSI_SP27XX_TXDCORE50_TX_C0F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(2), (SRIO_SERDES_TX50_C0F<<LSI_SP27XX_TXDCORE50_TX_C0F_BO)\
														|(SRIO_SERDES_TX50_C0O<<LSI_SP27XX_TXDCORE50_TX_C0O_BO)\
														|(SRIO_SERDES_TX50_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO)\
														|(SRIO_SERDES_TX50_CP1O<<LSI_SP27XX_TXDCORE50_TX_CP1O_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(3),
						(LSI_SP27XX_TXDCORE50_TX_C0O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
						(LSI_SP27XX_TXDCORE50_TX_C0F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE50_RA(3), (SRIO_SERDES_TX50_C0F<<LSI_SP27XX_TXDCORE50_TX_C0F_BO)\
														|(SRIO_SERDES_TX50_C0O<<LSI_SP27XX_TXDCORE50_TX_C0O_BO)\
														|(SRIO_SERDES_TX50_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO)\
														|(SRIO_SERDES_TX50_CP1O<<LSI_SP27XX_TXDCORE50_TX_CP1O_BO));

	/*RX 0/1/2/3 register control 1 RX_LOSVREFO = b1, RX_LOSVREFF[4:0] = b01001 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(0),
						LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM,
						LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(0), (SRIO_SERDES_RX1_LOSVREFO<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)\
															|(SRIO_SERDES_RX1_LOSVREFF<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(1),
						LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM,
						LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(1), (SRIO_SERDES_RX1_LOSVREFO<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)\
															|(SRIO_SERDES_RX1_LOSVREFF<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(2),
						LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM,
						LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(2), (SRIO_SERDES_RX1_LOSVREFO<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)\
															|(SRIO_SERDES_RX1_LOSVREFF<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(3),
						LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM,
						LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE1_RA(3), (SRIO_SERDES_RX1_LOSVREFO<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)\
															|(SRIO_SERDES_RX1_LOSVREFF<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	/*RX 0 register control 3 RX_FETRIMENO = b1, RX_FETRIMENF = b0 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(0),
						LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM,
						LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(0), (SRIO_SERDES_RX3_FETRIMENO<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
															|(SRIO_SERDES_RX3_FETRIMENF<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(1),
						LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM,
						LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(1), (SRIO_SERDES_RX3_FETRIMENO<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
															|(SRIO_SERDES_RX3_FETRIMENF<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(2),
						LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM,
						LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(2), (SRIO_SERDES_RX3_FETRIMENO<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
															|(SRIO_SERDES_RX3_FETRIMENF<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(3),
						LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM,
						LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE3_RA(3), (SRIO_SERDES_RX3_FETRIMENO<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
															|(SRIO_SERDES_RX3_FETRIMENF<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO));

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_CAR_SERDES_TRIMDONE_RA, LSI_SP27XX_SERDES_TRIMDONE_SERDES_TRIMDONE_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* SPLL CKDIS=1 & FPLL CKDIS=1 */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);
	/* FPLL_CAL =0 & SPLL_CAL =0 */
	REG32_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CAL_BM);
	/* FPLL_CAL =0 & SPLL_CAL =1 */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM);

	/* TX_RESETO =1, TX_RESETF=1*/
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(2), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(3), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

	/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(0),
						LSI_SP27XX_TXDCORE47_TX_DRO_BM,
						LSI_SP27XX_TXDCORE47_TX_DRF_BM);
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(1),
						LSI_SP27XX_TXDCORE47_TX_DRO_BM,
						LSI_SP27XX_TXDCORE47_TX_DRF_BM);
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(2),
						LSI_SP27XX_TXDCORE47_TX_DRO_BM,
						LSI_SP27XX_TXDCORE47_TX_DRF_BM);
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(2), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(3),
						LSI_SP27XX_TXDCORE47_TX_DRO_BM,
						LSI_SP27XX_TXDCORE47_TX_DRF_BM);
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(3), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/* RX_RESETO =1, RX_RESETF=1*/
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(2), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(3), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);

	/* RX_DR0=1, RX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(0),
						LSI_SP27XX_RXDCORE0_RX_DRO_BM,
						LSI_SP27XX_RXDCORE0_RX_DRF_BM);
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_DRO_BM|(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO)));

	/* RX_DR0=1, RX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(1),
						LSI_SP27XX_RXDCORE0_RX_DRO_BM,
						LSI_SP27XX_RXDCORE0_RX_DRF_BM);
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_DRO_BM|(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO)));

	/* RX_DR0=1, RX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(2),
						LSI_SP27XX_RXDCORE0_RX_DRO_BM,
						LSI_SP27XX_RXDCORE0_RX_DRF_BM);
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(2), LSI_SP27XX_RXDCORE0_RX_DRO_BM|(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO)));

	/* RX_DR0=1, RX_DRF[1:0]  =2'b00 */
	SERDES_RESET_BITS(	LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(3),
						LSI_SP27XX_RXDCORE0_RX_DRO_BM,
						LSI_SP27XX_RXDCORE0_RX_DRF_BM);
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(3), LSI_SP27XX_RXDCORE0_RX_DRO_BM|(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO)));

	/* FPLL_CAL = 1 & SPLL_CAL = 1 */
	REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CAL_BM);

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_SRIO_SERDES_CMUSTATUS31_RA, LSI_SP27XX_CMUSTATUS31_PLL_READY_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* reset TX RESETF */
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(2), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(3), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);

	/* reset RX RESETF */
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(2), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(3), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);

	 /* program  FPLL_CKDIS = 0 */
	SERDES_RESET_BITS(LSI_SP27XX_SRIO_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM, LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_SRIO_SERDES_CMUSTATUS31_RA, LSI_SP27XX_CMUSTATUS31_PLL_TXREADY_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_SRIO_SERDES_RXDCORE11_RA(0), LSI_SP27XX_RXDCORE11_RX_TRIMDONE_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	if (lane_mode == sRIO_1x4_mode)
	{
	    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_SRIO_SERDES_RXDCORE11_RA(1), LSI_SP27XX_RXDCORE11_RX_TRIMDONE_BM, timeout)) {
	        /* timeout error */
	    	return (ERROR);
	    }

	    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_SRIO_SERDES_RXDCORE11_RA(2), LSI_SP27XX_RXDCORE11_RX_TRIMDONE_BM, timeout)) {
	        /* timeout error */
	    	return (ERROR);
	    }
	}

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_SRIO_SERDES_RXDCORE11_RA(3), LSI_SP27XX_RXDCORE11_RX_TRIMDONE_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* Enable the internal phase transfer fifo */
	REG32_SET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(0),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	REG32_SET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(1),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	REG32_SET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(2),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	REG32_SET_BITS(	LSI_SP27XX_SRIO_SERDES_TXDCORE49_RA(3),
						LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

	/* Power down the lanes that are unused */
	if ((lane_mode == sRIO_2x1_mode) || (lane_mode == sRIO0_x1_mode) || (lane_mode == sRIO1_x1_mode)) //power down lanes 1 and 2
	{
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(1), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(1), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(2), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(2), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
	}

	if (lane_mode == sRIO0_x1_mode) //power down lane 3 if using sRIO0 only
	{
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(3), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(3), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
	}

	if (lane_mode == sRIO1_x1_mode) //power down lane 0 if using sRIO1 only
	{
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_TXDCORE47_RA(0), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_SRIO_SERDES_RXDCORE0_RA(0), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
	}

	/* Put the SerDes into normal mode */
	REG32_RESET_BITS(LSI_SP27XX_CAR_SRIO_SERDES_UPDATE_RA, LSI_SP27XX_SRIO_SERDES_UPDATE_SRIO_SERDES_UPDATE_BM);

	return(SUCCESS);
}

/* Each time this function is called with a valid speed value, a reset is performed on the whole sRIO SerDes
 * block.
 */
/* This function assumes that a 100 MHz SerDes reference clock is used for the PCIe SerDes */
/* Since this function should only be used to initialize the PCIe SerDes for SerDes testing purposes,
 * this function will place PIPE lanes 0 and 1 into reset, and will hold the PCIe interface
 * in reset.
 */
int32_t sp_PcieSerdesInit(serdesRateCfg_t speed, uint8_t ckiInMHz)
{
	uint32_t temp;

	uint32_t DRF, TX_CP1F, TX_RISEFALLF;

	uint32_t timeout = sp_timeoutValUsing32bitRTC(1000, ckiInMHz); /* >= 1 ms */

	if (speed == GBAUD_2_5) //2.5 GBAUD (100 MHz refclk, m1=1, m2=5, m3=5, m4=1, drf=2)
	{
		DRF = 0x1;
		TX_CP1F = 0x1;
		TX_RISEFALLF = 0x2;
	}
	else if (speed == GBAUD_5_0) //5.0 GBAUD (100 MHz refclk, m1=1, m2=5, m3=5, m4=1, drf=1)
	{
		DRF = 0x0;
		TX_CP1F = 0x3;
		TX_RISEFALLF = 0x0;
	}
	else if (speed == DISABLE_SERDES)
	{
		/* Power down the transmitter(s) and receiver(s) */
		REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(0), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(0), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(1), (0x1<<LSI_SP27XX_TXDCORE47_TX_PDO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE47_TX_PDF_BO));
		REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(1), (0x1<<LSI_SP27XX_RXDCORE0_RX_PDO_BO)\
																|(0x1<<LSI_SP27XX_RXDCORE0_RX_PDF_BO));

		return(SUCCESS);
	}
	else /* An incorrect parameter was passed in */
		return(ERROR);

	/* Put the PCIe interface into reset if it isn't already in reset */
	REG32_READ(LSI_SP27XX_CAR_RSTCTL_RA, temp);

	if ((temp & LSI_SP27XX_RSTCTL_SWRESET_PCIE_BM) != LSI_SP27XX_RSTCTL_SWRESET_PCIE_BM)
	{
		/* Put the PCIe PIPE lanes 0 and 1 into reset if not already in reset */
		REG32_READ(LSI_SP27XX_PCIE_PIPE_LAYER_PIPE_RST_EN_RA, temp);

		if((temp & LSI_SP27XX_PIPE_RST_EN_PPE_RSTN_EN_BM) != ((0x3 << LSI_SP27XX_PIPE_RST_EN_PPE_RSTN_EN_BO) & LSI_SP27XX_PIPE_RST_EN_PPE_RSTN_EN_BM))
			REG32_SET_BITS(LSI_SP27XX_PCIE_PIPE_LAYER_PIPE_RST_EN_RA, (LSI_SP27XX_PIPE_RST_EN_PPE_RSTN_EN_BM & (0x3<<LSI_SP27XX_PIPE_RST_EN_PPE_RSTN_EN_BO)));

		REG32_WRITE(LSI_SP27XX_CAR_RSTPROT_RA, 0x50F1C917); // Unlock the SW_RESET register
		REG32_SET_BITS(LSI_SP27XX_CAR_RSTCTL_RA, LSI_SP27XX_RSTCTL_SWRESET_PCIE_BM);  // Put the PCIe interface into reset
		REG32_WRITE(LSI_SP27XX_CAR_RSTPROT_RA, 0); // Re-lock the SW_RESET register
	}

	/* Perform a master software reset of the SerDes interface */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_CMUSWRESET_BM);
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_CMUSWRESET_BM);

	/********************* FIRST DO PLL SETUP **********************/

	/* PLL Cal Deassert */
	/* FPLL_CAL =0 & SPLL_CAL =0 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CAL_BM);
	/* FPLL_CAL =0 & SPLL_CAL =1 */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM);

	/* MODESELB=0, select A settings */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_FPLL_MODESELB_BM|LSI_SP27XX_CMUCNTRL0_SPLL_MODESELB_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, (0x1<<LSI_SP27XX_CMUCNTRL0_SPLL_MODESELB_BO));

	/* Disable the DUALMODE bit */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_DUALMODE_BM|LSI_SP27XX_CMUCNTRL0_FPLL_DUALMODE_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, (0x1<<LSI_SP27XX_CMUCNTRL0_SPLL_DUALMODE_BO));
	
	/* SPLL CKDIS=1 & FPLL CKDIS=1 */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

	/* CMUPD=0, L1PD=0 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_FPLL_CMUPD_BM|LSI_SP27XX_CMUCNTRL0_SPLL_CMUPD_BM\
			|LSI_SP27XX_CMUCNTRL0_FPLL_L1PD_BM|LSI_SP27XX_CMUCNTRL0_SPLL_L1PD_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CMUPD_BM|LSI_SP27XX_CMUCNTRL0_SPLL_L1PD_BM);

	/* PLLA, VCOSEL0, select low range VCO for A settings */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL1_RA, (0x1<<LSI_SP27XX_CMUCNTRL1_SPLLA_VCOSEL_BO)\
														|(0x0<<LSI_SP27XX_CMUCNTRL1_FPLLA_VCOSEL_BO));

	/* Set the M1 and M2 sub-dividers */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL1_RA, LSI_SP27XX_CMUCNTRL1_SPLLA_MDIV1_BM|LSI_SP27XX_CMUCNTRL1_FPLLA_MDIV1_BM\
														|LSI_SP27XX_CMUCNTRL1_SPLLA_MDIV2_BM|LSI_SP27XX_CMUCNTRL1_FPLLA_MDIV2_BM);

	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL1_RA, (0x1<<LSI_SP27XX_CMUCNTRL1_SPLLA_MDIV1_BO)\
														|(0x0<<LSI_SP27XX_CMUCNTRL1_FPLLA_MDIV1_BO));

	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL1_RA, (0x1<<LSI_SP27XX_CMUCNTRL1_SPLLA_MDIV2_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL1_FPLLA_MDIV2_BO));

	/* Set the M3 and M4 sub-dividers */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL2_RA, LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV3_BM|LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV3_BM\
														|LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV4_BM|LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV4_BM);

	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL2_RA, (0x1<<LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV3_BO)\
														|(0x4<<LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV3_BO));

	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL2_RA, (0x1<<LSI_SP27XX_CMUCNTRL2_SPLLA_MDIV4_BO)\
														|(0x0<<LSI_SP27XX_CMUCNTRL2_FPLLA_MDIV4_BO));

	/* PLL_ICP Charge pump current 0b'0101 */
	/* PLL_RES damping factor 0b'000 */
	/* PLL_RBCAP ripple bypass cap 0b'00 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL5_RA, LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BM|LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BM\
																|LSI_SP27XX_CMUCNTRL5_SPLL_RES_BM|LSI_SP27XX_CMUCNTRL5_FPLL_RES_BM\
																|LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BM|LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL5_RA, (0x1<<LSI_SP27XX_CMUCNTRL5_SPLL_ICP_BO)\
														|(0x5<<LSI_SP27XX_CMUCNTRL5_FPLL_ICP_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL5_SPLL_RES_BO)\
														|(0x0<<LSI_SP27XX_CMUCNTRL5_FPLL_RES_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL5_SPLL_RBCAP_BO)\
														|(0x0<<LSI_SP27XX_CMUCNTRL5_FPLL_RBCAP_BO));

	/* BGTC 0b'101, temp coefficient of 0 */
	/* CMUVR=0b'100 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL6_RA, LSI_SP27XX_CMUCNTRL6_SPLL_CMUVR_BM|LSI_SP27XX_CMUCNTRL6_FPLL_CMUVR_BM\
														|LSI_SP27XX_CMUCNTRL6_SPLL_BGTC_BM|LSI_SP27XX_CMUCNTRL6_FPLL_BGTC_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL6_RA, (0x1<<LSI_SP27XX_CMUCNTRL6_SPLL_CMUVR_BO)\
														|(0x4<<LSI_SP27XX_CMUCNTRL6_FPLL_CMUVR_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL6_SPLL_BGTC_BO)\
														|(0x5<<LSI_SP27XX_CMUCNTRL6_FPLL_BGTC_BO));

	/* REFINSELC=0 for CML */
	/* BGSV=0b'100 for 450mV */
	/* SPAREIN 0b'000 */
	/*CMU7 register SPLL_BGSV=b1, FPLL_BGSV[2:0]=b100, SPLL_SPAREIN=b1, FPLL_SPAREIN=b0000 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL7_RA, LSI_SP27XX_CMUCNTRL7_SPLL_BGSV_BM|LSI_SP27XX_CMUCNTRL7_FPLL_BGSV_BM\
														  |LSI_SP27XX_CMUCNTRL7_SPLL_SPAREIN_BM|LSI_SP27XX_CMUCNTRL7_FPLL_SPAREIN_BM\
														  |LSI_SP27XX_CMUCNTRL7_SREFINSELC_BM|LSI_SP27XX_CMUCNTRL7_FREFINSELC_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL7_RA, (0x1<<LSI_SP27XX_CMUCNTRL7_SPLL_BGSV_BO)\
													   |(0x4<<LSI_SP27XX_CMUCNTRL7_FPLL_BGSV_BO)\
													   |(0x1<<LSI_SP27XX_CMUCNTRL7_SPLL_SPAREIN_BO)\
													   |(0x0<<LSI_SP27XX_CMUCNTRL7_FPLL_SPAREIN_BO)\
													   |(0x1<<LSI_SP27XX_CMUCNTRL7_SREFINSELC_BO)\
													   |(0x0<<LSI_SP27XX_CMUCNTRL7_FREFINSELC_BO));

	/* TXCDREN=0 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL8_RA, LSI_SP27XX_CMUCNTRL8_FPLL_TXCDREN_BM|LSI_SP27XX_CMUCNTRL8_SPLL_TXCDREN_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL8_RA, (0x1<<LSI_SP27XX_CMUCNTRL8_SPLL_TXCDREN_BO)\
													   |(0x0<<LSI_SP27XX_CMUCNTRL8_FPLL_TXCDREN_BO));

	/* SLCTRL=0b'100 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL9_RA, LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BM|LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL9_RA, (0x1<<LSI_SP27XX_CMUCNTRL9_SPLL_SLCTRL_BO)\
													   |(0x4<<LSI_SP27XX_CMUCNTRL9_FPLL_SLCTRL_BO));

	/* REFBUF_PD=0 */
	/* SELI=0b'100 */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL10_RA, LSI_SP27XX_CMUCNTRL10_SPLLA_SELI_BM|LSI_SP27XX_CMUCNTRL10_FPLLA_SELI_BM\
			|LSI_SP27XX_CMUCNTRL10_FREFBUF_PD_BM|LSI_SP27XX_CMUCNTRL10_SREFBUF_PD_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL10_RA, (0x1<<LSI_SP27XX_CMUCNTRL10_SPLLA_SELI_BO)\
														|(0x4<<LSI_SP27XX_CMUCNTRL10_FPLLA_SELI_BO)\
														|(0x1<<LSI_SP27XX_CMUCNTRL10_SREFBUF_PD_BO)\
														|(0x0<<LSI_SP27XX_CMUCNTRL10_FREFBUF_PD_BO));

	/********************* SECOND DO RECEIVER SETUP **********************/

	/* WORDMODE=00 for 10 bit, DR=00 for FDR */
	/* hold RX in reset, override LOSFILTERENA, INV, PD, RESET,
	 * override WORDMODE and DR */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(0),
						(LSI_SP27XX_RXDCORE0_RX_DRO_BM|
								LSI_SP27XX_RXDCORE0_RX_WORDMODEO_BM|
								LSI_SP27XX_RXDCORE0_RX_INVO_BM|
								LSI_SP27XX_RXDCORE0_RX_PDO_BM|
								LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAO_BM),
						(LSI_SP27XX_RXDCORE0_RX_DRF_BM|
								LSI_SP27XX_RXDCORE0_RX_WORDMODE_BM|
								LSI_SP27XX_RXDCORE0_RX_INVF_BM|
								LSI_SP27XX_RXDCORE0_RX_PDF_BM|
								LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAF_BM));
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_DRO_BM|
			(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO))|
			LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAO_BM|
			LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAF_BM);

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(1),
						(LSI_SP27XX_RXDCORE0_RX_DRO_BM|
								LSI_SP27XX_RXDCORE0_RX_WORDMODEO_BM|
								LSI_SP27XX_RXDCORE0_RX_INVO_BM|
								LSI_SP27XX_RXDCORE0_RX_PDO_BM|
								LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAO_BM),
						(LSI_SP27XX_RXDCORE0_RX_DRF_BM|
								LSI_SP27XX_RXDCORE0_RX_WORDMODE_BM|
								LSI_SP27XX_RXDCORE0_RX_INVF_BM|
								LSI_SP27XX_RXDCORE0_RX_PDF_BM|
								LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAF_BM));
	/*RX_DRO=1, RX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_DRO_BM|
			(LSI_SP27XX_RXDCORE0_RX_DRF_BM & (DRF<<LSI_SP27XX_RXDCORE0_RX_DRF_BO))|
			LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAO_BM|
			LSI_SP27XX_RXDCORE0_RX_LOSFILTERNAF_BM);

	/* Gen2, P#SPDO, LOSVREFO, HOTINSERTO, LOSVREF=00110 */
	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE1_RA(0),(LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM|LSI_SP27XX_RXDCORE1_RX_GEN3O_BM|LSI_SP27XX_RXDCORE1_RX_P0SPDO_BM|LSI_SP27XX_RXDCORE1_RX_P1SPDO_BM|LSI_SP27XX_RXDCORE1_RX_P2SPDO_BM),(LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM|LSI_SP27XX_RXDCORE1_RX_GEN3F_BM|LSI_SP27XX_RXDCORE1_RX_P0SPDF_BM|LSI_SP27XX_RXDCORE1_RX_P1SPDF_BM|LSI_SP27XX_RXDCORE1_RX_P2SPDF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE1_RA(0), (0x1<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)|(0x5<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE1_RA(1),(LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BM|LSI_SP27XX_RXDCORE1_RX_GEN3O_BM|LSI_SP27XX_RXDCORE1_RX_P0SPDO_BM|LSI_SP27XX_RXDCORE1_RX_P1SPDO_BM|LSI_SP27XX_RXDCORE1_RX_P2SPDO_BM),(LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BM|LSI_SP27XX_RXDCORE1_RX_GEN3F_BM|LSI_SP27XX_RXDCORE1_RX_P0SPDF_BM|LSI_SP27XX_RXDCORE1_RX_P1SPDF_BM|LSI_SP27XX_RXDCORE1_RX_P2SPDF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE1_RA(1), (0x1<<LSI_SP27XX_RXDCORE1_RX_LOSVREFO_BO)|(0x5<<LSI_SP27XX_RXDCORE1_RX_LOSVREFF_BO));

	/* RXFETRIM=1, EQADAPTEN=0, EQDFEEN=1, EQMANSEL=0, EQALGO=010, IDDTN=1 */
	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE3_RA(0),
						(LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADAPTENO_BM|
								LSI_SP27XX_RXDCORE3_RX_EQDFEENAO_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADPALGORO_BM|
								LSI_SP27XX_RXDCORE3_LSI_IDDTNO_BM),
						(LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADAPTENF_BM|
								LSI_SP27XX_RXDCORE3_RX_EQDFEENAF_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADPALGORF_BM|
								LSI_SP27XX_RXDCORE3_LSI_IDDTNF_BM));
	REG32_SET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE3_RA(0),
						(0x1<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQADAPTENO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQDFEENAO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQADPALGORO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_LSI_IDDTNO_BO)\
						|(0x0<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO)\
						|(0x0<<LSI_SP27XX_RXDCORE3_RX_EQADAPTENF_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQDFEENAF_BO)\
						|(0x2<<LSI_SP27XX_RXDCORE3_RX_EQADPALGORF_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_LSI_IDDTNF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE3_RA(1),
						(LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADAPTENO_BM|
								LSI_SP27XX_RXDCORE3_RX_EQDFEENAO_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADPALGORO_BM|
								LSI_SP27XX_RXDCORE3_LSI_IDDTNO_BM),
						(LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADAPTENF_BM|
								LSI_SP27XX_RXDCORE3_RX_EQDFEENAF_BM|
								LSI_SP27XX_RXDCORE3_RX_EQADPALGORF_BM|
								LSI_SP27XX_RXDCORE3_LSI_IDDTNF_BM));
	REG32_SET_BITS(	LSI_SP27XX_PCIE_SERDES_RXDCORE3_RA(1),
						(0x1<<LSI_SP27XX_RXDCORE3_RX_FETRIMENO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQADAPTENO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQDFEENAO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQADPALGORO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_LSI_IDDTNO_BO)\
						|(0x0<<LSI_SP27XX_RXDCORE3_RX_FETRIMENF_BO)\
						|(0x0<<LSI_SP27XX_RXDCORE3_RX_EQADAPTENF_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_RX_EQDFEENAF_BO)\
						|(0x2<<LSI_SP27XX_RXDCORE3_RX_EQADPALGORF_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE3_LSI_IDDTNF_BO));

	/* EQADPLPLNC=01111 */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE4_RA(0),
						LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCO_BM,
						LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCF_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE4_RA(0),
						(0x1<<LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCF_BO));

	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE4_RA(1),
						LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCO_BM,
						LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCF_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE4_RA(1),
						(0x1<<LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE4_RX_EQADPLPLNCF_BO));

	/* EQADPUPLNC=01111 */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE5_RA(0),
						LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCO_BM,
						LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCF_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE5_RA(0),
						(0x1<<LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCF_BO));

	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE5_RA(1),
						LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCO_BM,
						LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCF_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE5_RA(1),
						(0x1<<LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE5_RX_EQADPUPLNCF_BO));

	/* ADP LGLNR=00000, UGLNR=11111 */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE6_RA(0),
						(LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRO_BM|LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRO_BM),
						(LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRF_BM|LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE6_RA(0),
						(0x1<<LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRF_BO)\
						|(0x1F<<LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRF_BO));

	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE6_RA(1),
						(LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRO_BM|LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRO_BM),
						(LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRF_BM|LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE6_RA(1),
						(0x1<<LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE6_RX_EQADPLGLNRF_BO)\
						|(0x1F<<LSI_SP27XX_RXDCORE6_RX_EQDADPUGLNRF_BO));

	/* DFE LINR=10000, LINC=10000 */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE7_RA(0),
						(LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRO_BM|LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCO_BM),
						(LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRF_BM|LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE7_RA(0),
						(0x1<<LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRF_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCF_BO));

	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE7_RA(1),
						(LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRO_BM|LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCO_BM),
						(LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRF_BM|LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE7_RA(1),
						(0x1<<LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRO_BO)\
						|(0x1<<LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCO_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE7_RX_EQDFEGLINRF_BO)\
						|(0x10<<LSI_SP27XX_RXDCORE7_RX_EQDFEPLINCF_BO));

	/********************* FINALLY DO TRANSMIT SETUP **********************/

	/* Reg 47 TX reset, WORDMODE=00, DR=00, INVO, PDO */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(0),
						(LSI_SP27XX_TXDCORE47_TX_DRO_BM|
								LSI_SP27XX_TXDCORE47_TX_WORDMODEO_BM|
								LSI_SP27XX_TXDCORE47_TX_PDO_BM|
								LSI_SP27XX_TXDCORE47_TX_INVO_BM),
						(LSI_SP27XX_TXDCORE47_TX_DRF_BM|
								LSI_SP27XX_TXDCORE47_TX_WORDMODE_BM|
								LSI_SP27XX_TXDCORE47_TX_PDF_BM|
								LSI_SP27XX_TXDCORE47_TX_INVF_BM));
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(1),
						(LSI_SP27XX_TXDCORE47_TX_DRO_BM|
								LSI_SP27XX_TXDCORE47_TX_WORDMODEO_BM|
								LSI_SP27XX_TXDCORE47_TX_PDO_BM|
								LSI_SP27XX_TXDCORE47_TX_INVO_BM),
						(LSI_SP27XX_TXDCORE47_TX_DRF_BM|
								LSI_SP27XX_TXDCORE47_TX_WORDMODE_BM|
								LSI_SP27XX_TXDCORE47_TX_PDF_BM|
								LSI_SP27XX_TXDCORE47_TX_INVF_BM));
	/*TX_DRO=1, TX_DRF[1:0]  =2'b{DRF} */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_DRO_BM|(LSI_SP27XX_TXDCORE47_TX_DRF_BM & (DRF<<LSI_SP27XX_TXDCORE47_TX_DRF_BO)));

	/* RXdetect reset, RXdetect disable, TxIdle disable and TxValid enable */
	/* Gen2 */
	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE48_RA(0),
							(LSI_SP27XX_TXDCORE48_TX_RXDETRESETO_BM|
									LSI_SP27XX_TXDCORE48_TX_RXDETENAO_BM|
									LSI_SP27XX_TXDCORE48_TX_IDLEO_BM|
									LSI_SP27XX_TXDCORE48_TX_VALIDO_BM|
									LSI_SP27XX_TXDCORE48_TX_P1SPDO_BM|
									LSI_SP27XX_TXDCORE48_TX_GEN3O_BM),
							(LSI_SP27XX_TXDCORE48_TX_RXDETRESETF_BM|
									LSI_SP27XX_TXDCORE48_TX_RXDETENAF_BM|
									LSI_SP27XX_TXDCORE48_TX_IDLEF_BM|
									LSI_SP27XX_TXDCORE48_TX_VALIDF_BM|
									LSI_SP27XX_TXDCORE48_TX_P1SPDF_BM|
									LSI_SP27XX_TXDCORE48_TX_GEN3F_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE48_RA(0), (0x1<<LSI_SP27XX_TXDCORE48_TX_VALIDO_BO)
																|(0x1<<LSI_SP27XX_TXDCORE48_TX_VALIDF_BO)|
																(0x1<<LSI_SP27XX_TXDCORE48_TX_RXDETRESETO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE48_TX_RXDETRESETF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE48_RA(1),
							(LSI_SP27XX_TXDCORE48_TX_RXDETRESETO_BM|
									LSI_SP27XX_TXDCORE48_TX_RXDETENAO_BM|
									LSI_SP27XX_TXDCORE48_TX_IDLEO_BM|
									LSI_SP27XX_TXDCORE48_TX_VALIDO_BM|
									LSI_SP27XX_TXDCORE48_TX_P1SPDO_BM|
									LSI_SP27XX_TXDCORE48_TX_GEN3O_BM),
							(LSI_SP27XX_TXDCORE48_TX_RXDETRESETF_BM|
									LSI_SP27XX_TXDCORE48_TX_RXDETENAF_BM|
									LSI_SP27XX_TXDCORE48_TX_IDLEF_BM|
									LSI_SP27XX_TXDCORE48_TX_VALIDF_BM|
									LSI_SP27XX_TXDCORE48_TX_P1SPDF_BM|
									LSI_SP27XX_TXDCORE48_TX_GEN3F_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE48_RA(1), (0x1<<LSI_SP27XX_TXDCORE48_TX_VALIDO_BO)
																|(0x1<<LSI_SP27XX_TXDCORE48_TX_VALIDF_BO)|
																(0x1<<LSI_SP27XX_TXDCORE48_TX_RXDETRESETO_BO)\
																|(0x1<<LSI_SP27XX_TXDCORE48_TX_RXDETRESETF_BO));

	/* FIFO disable, SPAREINO */
	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE49_RA(0),
							(LSI_SP27XX_TXDCORE49_TX_SPAREINO_BM|LSI_SP27XX_TXDCORE49_TX_FIFOENO_BM),
							(LSI_SP27XX_TXDCORE49_TX_SPAREINF_BM|LSI_SP27XX_TXDCORE49_TX_FIFOENF_BM));

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE49_RA(1),
							(LSI_SP27XX_TXDCORE49_TX_SPAREINO_BM|LSI_SP27XX_TXDCORE49_TX_FIFOENO_BM),
							(LSI_SP27XX_TXDCORE49_TX_SPAREINF_BM|LSI_SP27XX_TXDCORE49_TX_FIFOENF_BM));

	/* TX post and precursor overrides, CP=CM=0 */
	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE50_RA(0),
							(LSI_SP27XX_TXDCORE50_TX_CM1O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
							(LSI_SP27XX_TXDCORE50_TX_CM1F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE50_RA(0), ((TX_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO) & LSI_SP27XX_TXDCORE50_TX_CP1F_BM)|
			LSI_SP27XX_TXDCORE50_TX_CP1O_BM);

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE50_RA(1),
							(LSI_SP27XX_TXDCORE50_TX_CM1O_BM|LSI_SP27XX_TXDCORE50_TX_CP1O_BM),
							(LSI_SP27XX_TXDCORE50_TX_CM1F_BM|LSI_SP27XX_TXDCORE50_TX_CP1F_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE50_RA(1), ((TX_CP1F<<LSI_SP27XX_TXDCORE50_TX_CP1F_BO) & LSI_SP27XX_TXDCORE50_TX_CP1F_BM)|
			LSI_SP27XX_TXDCORE50_TX_CP1O_BM);

	/* TX rise fall=000, amplitude=1111, no RXTX_TERM=5 */
	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE51_RA(0),
							(LSI_SP27XX_TXDCORE51_TX_RISEFALLO_BM|
									LSI_SP27XX_TXDCORE51_TX_AMPO_BM|
									LSI_SP27XX_TXDCORE51_RXTX_TERMO_BM),
							(LSI_SP27XX_TXDCORE51_TX_RISEFALLF_BM|
									LSI_SP27XX_TXDCORE51_TX_AMPF_BM|
									LSI_SP27XX_TXDCORE51_RXTX_TERMF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE51_RA(0), (0x1<<LSI_SP27XX_TXDCORE51_TX_RISEFALLO_BO)\
															|(0x1<<LSI_SP27XX_TXDCORE51_TX_AMPO_BO)\
															|(0x1<<LSI_SP27XX_TXDCORE51_RXTX_TERMO_BO)\
															|((TX_RISEFALLF<<LSI_SP27XX_TXDCORE51_TX_RISEFALLF_BO) & LSI_SP27XX_TXDCORE51_TX_RISEFALLF_BM)\
															|(0xC<<LSI_SP27XX_TXDCORE51_TX_AMPF_BO)\
															|(0x5<<LSI_SP27XX_TXDCORE51_RXTX_TERMF_BO));

	SERDES_RESET_BITS(	LSI_SP27XX_PCIE_SERDES_TXDCORE51_RA(1),
							(LSI_SP27XX_TXDCORE51_TX_RISEFALLO_BM|
									LSI_SP27XX_TXDCORE51_TX_AMPO_BM|
									LSI_SP27XX_TXDCORE51_RXTX_TERMO_BM),
							(LSI_SP27XX_TXDCORE51_TX_RISEFALLF_BM|
									LSI_SP27XX_TXDCORE51_TX_AMPF_BM|
									LSI_SP27XX_TXDCORE51_RXTX_TERMF_BM));
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE51_RA(1), (0x1<<LSI_SP27XX_TXDCORE51_TX_RISEFALLO_BO)\
															|(0x1<<LSI_SP27XX_TXDCORE51_TX_AMPO_BO)\
															|(0x1<<LSI_SP27XX_TXDCORE51_RXTX_TERMO_BO)\
															|((TX_RISEFALLF<<LSI_SP27XX_TXDCORE51_TX_RISEFALLF_BO) & LSI_SP27XX_TXDCORE51_TX_RISEFALLF_BM)\
															|(0xC<<LSI_SP27XX_TXDCORE51_TX_AMPF_BO)\
															|(0x5<<LSI_SP27XX_TXDCORE51_RXTX_TERMF_BO));

	/* XCKSEL BUT NO RXTX_PINO */
	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE38_RA(0),LSI_SP27XX_TXDCORE38_RXTX_PINO_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE38_RA(0), LSI_SP27XX_TXDCORE38_TX_XCKSELREG_BM);

	REG32_RESET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE38_RA(1),LSI_SP27XX_TXDCORE38_RXTX_PINO_BM);
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE38_RA(1), LSI_SP27XX_TXDCORE38_TX_XCKSELREG_BM);

	/********************* SETUP IS DONE **********************/

	/* FPLL_CAL = 1 & SPLL_CAL = 1 */
	REG32_SET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CAL_BM|LSI_SP27XX_CMUCNTRL0_FPLL_CAL_BM);

    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_PCIE_SERDES_CMUSTATUS31_RA, LSI_SP27XX_CMUSTATUS31_PLL_READY_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	/* Deassert RX resets */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(0), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_RXDCORE0_RA(1), LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);

	/* Deassert TX resets */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(0), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_TXDCORE47_RA(1), LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);

	/* CKDIS=0 */
	SERDES_RESET_BITS(LSI_SP27XX_PCIE_SERDES_CMUCNTRL0_RA, LSI_SP27XX_CMUCNTRL0_SPLL_CKDIS_BM, LSI_SP27XX_CMUCNTRL0_FPLL_CKDIS_BM);

	/* Wait for PLL_TXREADY=1 */
    if (sp_timeoutDuringWaitForRegBitSet(LSI_SP27XX_PCIE_SERDES_CMUSTATUS31_RA, LSI_SP27XX_CMUSTATUS31_PLL_TXREADY_BM, timeout)) {
        /* timeout error */
    	return (ERROR);
    }

	return(SUCCESS);
}

int32_t sp_GigeSerdesSetupLB(uint8_t channel, serdesLoopbackType_t loopback, uint8_t ckiInMHz)
{
	return(sp_SerdesSetupLB(GIGE_SERDES, loopback, channel, ckiInMHz));
}

int32_t sp_SrioSerdesSetupLB(uint8_t lane_mode, serdesLoopbackType_t loopback, uint8_t ckiInMHz)
{
	uint8_t channel = 0;

	if (lane_mode == sRIO_1x4_mode)
		channel = CHAN(0)|CHAN(1)|CHAN(2)|CHAN(3);
	else if (lane_mode == sRIO_2x1_mode)
		channel = CHAN(0)|CHAN(3);
	else if (lane_mode == sRIO0_x1_mode)
		channel = CHAN(0);
	else if (lane_mode == sRIO1_x1_mode)
		channel = CHAN(3);

	return(sp_SerdesSetupLB(SRIO_SERDES, loopback, channel, ckiInMHz));
}

int32_t sp_PcieSerdesSetupLB(uint8_t channel, serdesLoopbackType_t loopback, uint8_t ckiInMHz)
{
	return(sp_SerdesSetupLB(PCIE_SERDES, loopback, channel, ckiInMHz));
}

/* If the loopback type is any type of REVERSE LOOPBACK, the PRBS testing function does not enable the loopback;
 * rather, the PRBS testing function simply runs the generator and checker and reports the results. */
uint64_t sp_GigeSerdesPRBSChk(serdesLoopbackType_t loopback, serdesRateCfg_t rate, uint8_t ckiInMHz, uint8_t channel)
{
	serdesTestParams_t PRBStest;

	PRBStest.interface = GIGE_SERDES;
	PRBStest.rate = rate;
	PRBStest.lane = channel;
	PRBStest.loopback = loopback;
	PRBStest.poly = PRBS7;
	PRBStest.numwords = 0xFFFFLL;
	PRBStest.ckiInMHz = ckiInMHz;
	PRBStest.run4ever = run4ever_off; //Passing run4ever_on into sp_SerdesPRBSChk() is not recommended; it will fail because PCDONE will never be 1

	return (sp_SerdesPRBSChk(&PRBStest));
}

/* If the loopback type is any type of REVERSE_LOOPBACK, the PRBS testing function does not enable the loopback;
 * rather, the PRBS testing function simply runs the generator and checker and reports the results. */
uint64_t sp_SrioSerdesPRBSChk(serdesLoopbackType_t loopback, serdesRateCfg_t rate, uint8_t ckiInMHz, uint8_t lane_mode)
{
	uint8_t channel = 0;
	serdesTestParams_t PRBStest;

	if (lane_mode == sRIO_1x4_mode)
		channel = CHAN(0)|CHAN(1)|CHAN(2)|CHAN(3);
	else if (lane_mode == sRIO_2x1_mode)
		channel = CHAN(0)|CHAN(3);
	else if (lane_mode == sRIO0_x1_mode)
		channel = CHAN(0);
	else if (lane_mode == sRIO1_x1_mode)
		channel = CHAN(3);

	PRBStest.interface = SRIO_SERDES;
	PRBStest.rate = rate;
	PRBStest.lane = channel;
	PRBStest.loopback = loopback;
	PRBStest.poly = PRBS7;
	PRBStest.numwords = 0xFFFFLL;
	PRBStest.ckiInMHz = ckiInMHz;
	PRBStest.run4ever = run4ever_off; //Passing run4ever_on into sp_SerdesPRBSChk() is not recommended; it will fail because PCDONE will never be 1

	return (sp_SerdesPRBSChk(&PRBStest));
}

/* If the loopback type is any type of REVERSE_LOOPBACK, the PRBS testing function does not enable the loopback;
 * rather, the PRBS testing function simply runs the generator and checker and reports the results. */
uint64_t sp_PcieSerdesPRBSChk(serdesLoopbackType_t loopback, serdesRateCfg_t rate, uint8_t ckiInMHz, uint8_t channel)
{
	serdesTestParams_t PRBStest;

	PRBStest.interface = PCIE_SERDES;
	PRBStest.rate = rate;
	PRBStest.lane = channel;
	PRBStest.loopback = loopback;
	PRBStest.poly = PRBS7;
	PRBStest.numwords = 0xFFFFLL;
	PRBStest.ckiInMHz = ckiInMHz;
	PRBStest.run4ever = run4ever_off; //Passing run4ever_on into sp_SerdesPRBSChk() is not recommended; it will fail because PCDONE will never be 1

	return (sp_SerdesPRBSChk(&PRBStest));
}

int32_t sp_SerdesSetupLB(serdesInterface_t interface, serdesLoopbackType_t loopback, uint8_t channel, uint8_t ckiInMHz)
{
	uint32_t temp, temp1, temp2, status = SUCCESS;
	uint32_t chan_base[4] = {0};
	uint32_t base, num_channels;

	uint32_t timeout = sp_timeoutValUsing32bitRTC(1000, ckiInMHz); /* >= 1 ms */

	if (interface == SRIO_SERDES)
	{
		if ((channel != CHAN(0)) &&
			(channel != CHAN(3)) &&
			(channel != (CHAN(0)|CHAN(3))) &&
			(channel != (CHAN(0)|CHAN(1)|CHAN(2)|CHAN(3)))
			)
			return(ERROR); /* Channels to be looped back aren't based on the available valid options for sRIO */

		base = LSI_SP27XX_SRIO_SERDES_BASE;
		num_channels = 4;
	}
	else if (interface == GIGE_SERDES)
	{
#ifdef PCE_DEBUG
bsp_debug_printf("\r\n In GIGe_Sedes lpbk emac = %d, lopbk type = %d, gin = %d", channel, loopback, ckiInMHz);
#endif
		if ((channel != CHAN(0)) &&
			(channel != CHAN(1)) &&
			(channel != (CHAN(0)|CHAN(1)))
			) {

bsp_debug_printf("\r\n ERROR ERROR In GIGe_Sedes lpbk emac = %d, lopbk type = %d, gin = %d", channel, loopback, ckiInMHz);
			return(ERROR); /* Channels to be looped back aren't based on the available valid options for GIGE */
}

#ifdef PCE_DEBUG
bsp_debug_printf("\r\n In GIGe_Sedes lpbk emac = %d, lopbk type = %d, gin = %d", channel, loopback, ckiInMHz);
#endif
		base = LSI_SP27XX_GIGE_SERDES_BASE;
		num_channels = 2;
	}
	else if (interface == PCIE_SERDES)
	{
		if ((channel != CHAN(0)) &&
			(channel != CHAN(1)) &&
			(channel != (CHAN(0)|CHAN(1)))
			)
			return(ERROR); /* Channels to be looped back aren't based on the available valid options for PCIe */

		base = LSI_SP27XX_PCIE_SERDES_BASE;
		num_channels = 2;
	}
	else
		return(ERROR); /* The interface value is incorrect */

	for (temp = 0; temp < num_channels; temp++)
		chan_base[temp] = base + (temp * LSI_SP27XX_SERDES_IVL);

	switch (loopback)
	{
	case SERIAL_LOOPBACK:
#ifdef PCE_DEBUG
bsp_debug_printf("\r\n In GIGe_Sedes lpbk serial loopback emac = %d, lopbk type = %d, gin = %d", channel, loopback, ckiInMHz);
bsp_debug_printf("\n LSI_SP27XX_TXDCORE38_RO = 0x%x, temp = %d, base = 0x%x, chan_base[temp] = 0x%x", LSI_SP27XX_TXDCORE38_RO, temp, base, chan_base[temp]);
#endif
		for (temp = 0; temp < num_channels; temp++)
		{
			if ((channel & CHAN(temp)) == CHAN(temp))
				REG32_SET_BITS(LSI_SP27XX_TXDCORE38_RO + chan_base[temp], LSI_SP27XX_TXDCORE38_NSILB_BM);
		}

		break;

	case PARALLEL_LOOPBACK:
		for (temp = 0; temp < num_channels; temp++)
		{
			if ((channel & CHAN(temp)) == CHAN(temp))
				REG32_SET_BITS(LSI_SP27XX_TXDCORE38_RO + chan_base[temp], LSI_SP27XX_TXDCORE38_IPILB_BM);
		}

		/* Disable the TX CDR */
		SERDES_RESET_BITS(	LSI_SP27XX_CMUCNTRL8_RO + chan_base[0],
							LSI_SP27XX_CMUCNTRL8_SPLL_TXCDREN_BM,
							LSI_SP27XX_CMUCNTRL8_FPLL_TXCDREN_BM);

		break;

	/* The below reverse loopback procedure assumes a synchronous clock between this device and the link partner */
	case SYNC_REVERSE_LOOPBACK:
		for (temp = 0; temp < num_channels; temp++)
		{
			if ((channel & CHAN(temp)) == CHAN(temp))
			{
				REG32_SET_BITS(LSI_SP27XX_TXDCORE38_RO + chan_base[temp], LSI_SP27XX_TXDCORE38_NPILB_BM);
				REG32_SET_BITS(LSI_SP27XX_TXDCORE47_RO + chan_base[temp], LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);

				/* Disable internal phase transfer fifo */
				SERDES_RESET_BITS(	LSI_SP27XX_TXDCORE49_RO + chan_base[temp],
									LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
									LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
			}
		}

	    if (sp_timeoutDuringWaitForRegBitSet((LSI_SP27XX_CMUSTATUS31_RO + chan_base[0]), LSI_SP27XX_CMUSTATUS31_PLL_TXREADY_BM, timeout)) {
	        /* timeout error */
	    	status = ERROR;
	    }

		for (temp = 0; temp < num_channels; temp++)
		{
			if ((channel & CHAN(temp)) == CHAN(temp))
			{
				SERDES_RESET_BITS(LSI_SP27XX_TXDCORE47_RO + chan_base[temp], LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);

				/* Once the clocks are available, enable the internal phase transfer fifo */
				REG32_SET_BITS(	LSI_SP27XX_TXDCORE49_RO + chan_base[temp], LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
			}
		}

		break;

	/* The below reverse loopback procedure assumes an asynchronous clock between this device and the link partner */
	case ASYNC_REVERSE_LOOPBACK:
		for (temp = 0; temp < num_channels; temp++)
		{
			if ((channel & CHAN(temp)) == CHAN(temp))
			{
				REG32_SET_BITS(LSI_SP27XX_TXDCORE47_RO + chan_base[temp], LSI_SP27XX_TXDCORE47_TX_RESETF_BM|LSI_SP27XX_TXDCORE47_TX_RESETO_BM);
				REG32_SET_BITS(LSI_SP27XX_RXDCORE0_RO + chan_base[temp], LSI_SP27XX_RXDCORE0_RX_RESETF_BM|LSI_SP27XX_RXDCORE0_RX_RESETO_BM);

				/* Disable internal phase transfer fifo */
				SERDES_RESET_BITS(	LSI_SP27XX_TXDCORE49_RO + chan_base[temp],
									LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM,
									LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);

				/* NPILB -> Set reverse loopback */
				REG32_SET_BITS(LSI_SP27XX_TXDCORE38_RO + chan_base[temp], LSI_SP27XX_TXDCORE38_NPILB_BM);

				/* Clear RXA_PDXMTCLK to power up output buffers for transmitting the recovered clock */
				REG32_RESET_BITS(LSI_SP27XX_RXACORE21_RO + chan_base[temp], LSI_SP27XX_RXACORE21_RXA_PDXMTCLK_BM);

				/* Set TXA_RXCKEN to use the serial clock from RX */
				REG32_SET_BITS(LSI_SP27XX_TXACORE42_RO + chan_base[temp], LSI_SP27XX_TXACORE42_TXA_RXCKEN_BM);

				/* Get the current value of TX_DR.
				 * If the current value of TX_DR isn't full-rate (00), then this needs to be set to full-rate at
				 * the transmitter
				 */
				REG32_READ(LSI_SP27XX_TXDCORE39_RO + chan_base[temp], temp1);
				if (((temp1 & LSI_SP27XX_TXDCORE39_TX_DR_BM) >> LSI_SP27XX_TXDCORE39_TX_DR_BO) != 0x0)
				{
					/*TX_DR0=1, TX_DRF[1:0]  =2'b00 */
					SERDES_RESET_BITS(LSI_SP27XX_TXDCORE47_RO + chan_base[temp], LSI_SP27XX_TXDCORE47_TX_DRO_BM, LSI_SP27XX_TXDCORE47_TX_DRF_BM);
				}

				/* Set TX_VALID to 1 */
				REG32_SET_BITS(LSI_SP27XX_TXDCORE48_RO + chan_base[temp], LSI_SP27XX_TXDCORE48_TX_VALIDF_BM|LSI_SP27XX_TXDCORE48_TX_VALIDO_BM);

				/* The RX and TX resets can be cleared. Once data is being sent into
				 * the RXP/N, the RX CDR will eventually lock to the incoming data. */
				SERDES_RESET_BITS(LSI_SP27XX_TXDCORE47_RO + chan_base[temp], LSI_SP27XX_TXDCORE47_TX_RESETO_BM, LSI_SP27XX_TXDCORE47_TX_RESETF_BM);
				SERDES_RESET_BITS(LSI_SP27XX_RXDCORE0_RO + chan_base[temp], LSI_SP27XX_RXDCORE0_RX_RESETO_BM, LSI_SP27XX_RXDCORE0_RX_RESETF_BM);

				/* Enable the internal phase transfer fifo */
				REG32_SET_BITS(	LSI_SP27XX_TXDCORE49_RO + chan_base[temp], LSI_SP27XX_TXDCORE49_TX_FIFOWRENO_BM | LSI_SP27XX_TXDCORE49_TX_FIFOWRENF_BM);
			}
		}

		break;

	case DISABLE_LOOPBACK: /* DISABLE_LOOPBACK */
		for (temp = 0; temp < num_channels; temp++)
		{
			if ((channel & CHAN(temp)) == CHAN(temp))
			{
				REG32_RESET_BITS(LSI_SP27XX_TXDCORE38_RO + chan_base[temp], LSI_SP27XX_TXDCORE38_NSILB_BM|LSI_SP27XX_TXDCORE38_IPILB_BM|LSI_SP27XX_TXDCORE38_NPILB_BM);

				/* In the case that there was an asynchronous reverse loopback, the output buffers need to be powered down at the receiver
				 * so that the recovered clock is not transferred to the transmitter.
				 */
				REG32_SET_BITS(LSI_SP27XX_RXACORE21_RO + chan_base[temp], LSI_SP27XX_RXACORE21_RXA_PDXMTCLK_BM);

				/* In the case that there was an asynchronous reverse loopback, the transmitter must now not use the
				 * serial clock from the receiver.
				 */
				REG32_RESET_BITS(LSI_SP27XX_TXACORE42_RO + chan_base[temp], LSI_SP27XX_TXACORE42_TXA_RXCKEN_BM);

				/* Set the TX DR value to be the same as the RX DR value in case it was changed earlier in the asynchronous reverse loopback mode */
				REG32_READ(LSI_SP27XX_RXDCORE11_RO + chan_base[temp], temp1);
				temp2 = (temp1 & LSI_SP27XX_RXDCORE11_RX_DR_BM) >> LSI_SP27XX_RXDCORE11_RX_DR_BO;
				REG32_READ(LSI_SP27XX_TXDCORE39_RO + chan_base[temp], temp1);
				if (((temp1 & LSI_SP27XX_TXDCORE39_TX_DR_BM) >> LSI_SP27XX_TXDCORE39_TX_DR_BO) != temp2)
				{
					REG32_SET_BITS(	LSI_SP27XX_TXDCORE47_RO + chan_base[temp], LSI_SP27XX_TXDCORE47_TX_DRO_BM | (LSI_SP27XX_TXDCORE47_TX_DRF_BM & (temp1 << LSI_SP27XX_TXDCORE47_TX_DRF_BO)));
				}

				/* Re-enable the TX CDR just in case it was disabled earlier in the parallel loopback mode */
				REG32_SET_BITS(	LSI_SP27XX_CMUCNTRL8_RO + chan_base[0], LSI_SP27XX_CMUCNTRL8_SPLL_TXCDREN_BM | LSI_SP27XX_CMUCNTRL8_FPLL_TXCDREN_BM);
			}
		}

		break;

	default: /* wrong loopback parameter */
		status = ERROR;

		break;
	}

	return(status);
}

/* If the loopback type is any type of REVERSE LOOPBACK, the PRBS testing function does not enable the loopback;
 * rather, the PRBS testing function simply runs the generator and checker and reports the results. */
uint64_t
sp_SerdesPRBSChk(serdesTestParams_t *testParams)
{
	uint32_t temp;
	uint64_t status = SUCCESS;
	uint32_t num_channels;
	serdesPrbsChkrStat_t check;

	serdesInterface_t interface = testParams->interface;
	uint8_t channel = testParams->lane;
	serdesPrbsPoly_t polynomial = testParams->poly;
	uint64_t nwords = testParams->numwords;
	serdesLoopbackType_t loopback_type = testParams->loopback;
	serdesRateCfg_t rate = testParams->rate;
	uint8_t ckiInMHz = testParams->ckiInMHz;
	run4ever_t run4ever = testParams->run4ever;

	if (interface == SRIO_SERDES)
	{
		if ((channel != CHAN(0)) &&
			(channel != CHAN(3)) &&
			(channel != (CHAN(0)|CHAN(3))) &&
			(channel != (CHAN(0)|CHAN(1)|CHAN(2)|CHAN(3)))
			)
			return(MISC_ERR); /* Channel value is not valid */

		num_channels = 4;
	}
	else if (interface == GIGE_SERDES)
	{
		if ((channel != CHAN(0)) &&
			(channel != CHAN(1)) &&
			(channel != (CHAN(0)|CHAN(1)))
			)
			return(MISC_ERR); /* Channel value is not valid */

		num_channels = 2;
	}
	else if (interface == PCIE_SERDES)
	{
		if ((channel != CHAN(0)) &&
			(channel != CHAN(1)) &&
			(channel != (CHAN(0)|CHAN(1)))
			)
			return(MISC_ERR); /* Channel value is not valid */

		num_channels = 2;
	}
	else
		return(MISC_ERR); /* The interface value is incorrect */

	if ((rate != GBAUD_1_25) && (rate != GBAUD_2_5) && (rate != GBAUD_3_125) && (rate != GBAUD_5_0))
		return(MISC_ERR); /* A valid serial rate was not used */

	if (nwords > 0xFFFFFFFFFFLL)
		return(MISC_ERR); /* The word count is higher than what is supported */

	/* Setup the loopback path on SerDes if it is able to be tested internally */
	if ((loopback_type == SERIAL_LOOPBACK) || (loopback_type == PARALLEL_LOOPBACK))
	{
			if (sp_SerdesSetupLB(interface, loopback_type, channel, ckiInMHz) != SUCCESS)
				return(MISC_ERR); /* Setting up a loopback was unsuccessful */
	}

	/* Clear the PRBS checker status */
	sp_SerdesPrbsClearChkr(interface, channel);

	/* Enable the PRBS generator */
	if (sp_SerdesPrbsGenCtrl(PRBS_start, interface, channel, polynomial, ckiInMHz) != SUCCESS)
		return(MISC_ERR); /* Enabling the generator failed */

	/* Enable the PRBS checker */
	status |= sp_SerdesPrbsChkrCtrl(PRBS_start, interface, channel, polynomial, run4ever, nwords, ckiInMHz);

	if ((status & MISC_ERR) == MISC_ERR)
		return(status); /* Enabling the checker failed */

	/* Wait a certain amount of time before checking PCDONE */
	sp_SerdesPrbsWaitPcDone(rate, nwords, ckiInMHz);

	/* Retrieve and store PRBS checker status */
	for (temp = 0; temp < num_channels; temp++)
	{
		if ((channel & CHAN(temp)) == CHAN(temp))
		{
			check = sp_SerdesPrbsGetChkrStat(interface, temp);

			if (check.pcdone != 1)
			{
				status |= ERR_PCDONE_NEVER_SET_ON_CH(temp);
			}
			if (check.pcinsync != 1)
			{
				status |= ERR_NO_SYNC_ON_CH(temp);
			}
			if (check.pclos != 0)
			{
				status |= ERR_PCLOS_ASSERTED_ON_CH(temp);
			}
			if (check.pcerrof != 0)
			{
				status |= ERR_PCERROF_ASSERTED_ON_CH(temp);
			}
			if (check.pcworduf != 0)
			{
				status |= ERR_PCWORDUF_ASSERTED_ON_CH(temp);
			}
			if (check.pcsel != 1)
			{
				status |= ERR_PCSEL_NOT_ASSERTED_ON_CH(temp);
			}
			if (check.err_cnt != 0)
			{
				status |= ERRORS_FOUND_ON_CH(temp);
			}
			if (check.word_cnt != 0)
			{
				status |= ERR_PRBS_CHKR_CAPTURED_WORDS_ON_CH(temp);
			}
		}
	}

	/* Disable the PRBS Generator */
	if (sp_SerdesPrbsGenCtrl(PRBS_stop, interface, channel, polynomial, ckiInMHz) != SUCCESS)
		status |= MISC_ERR; /* Disabling the generator failed */

	/* Disable the PRBS Checker */
	status |= sp_SerdesPrbsChkrCtrl(PRBS_stop, interface, channel, polynomial, run4ever, nwords, ckiInMHz);

	/* Disable all SerDes loopbacks, if necessary */
	if ((loopback_type == SERIAL_LOOPBACK) || (loopback_type == PARALLEL_LOOPBACK))
	{
		if (sp_SerdesSetupLB(interface, DISABLE_LOOPBACK, channel, ckiInMHz) != SUCCESS)
			status |= MISC_ERR; /* Disabling a loopback failed */
	}

	return(status);
}

void sp_SerdesPrbsClearChkr(serdesInterface_t interface, uint8_t channel)
{
	uint32_t chan_base[4] = {0};
	uint32_t temp, temp1, base = 0, num_channels = 0;

	if (interface == SRIO_SERDES)
	{
		base = LSI_SP27XX_SRIO_SERDES_BASE;
		num_channels = 4;
	}
	else if (interface == GIGE_SERDES)
	{
		base = LSI_SP27XX_GIGE_SERDES_BASE;
		num_channels = 2;
	}
	else if (interface == PCIE_SERDES)
	{
		base = LSI_SP27XX_PCIE_SERDES_BASE;
		num_channels = 2;
	}

	for (temp = 0; temp < num_channels; temp++)
	{
		chan_base[temp] = base + (temp * LSI_SP27XX_SERDES_IVL);

		if ((channel & CHAN(temp)) == CHAN(temp))
		{
			REG32_READ(LSI_SP27XX_PRBS56_RO + chan_base[temp], temp1);

			if ((temp1 & LSI_SP27XX_PRBS56_PCSEL_BM) == LSI_SP27XX_PRBS56_PCSEL_BM)
			{
				/* Disable the PRBS checker if it is on */
				REG32_RESET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], LSI_SP27XX_PRBS56_PCSEL_BM);

				/* Clear the PRBS status register 61 (COR) */
				REG32_READ(LSI_SP27XX_PRBS61_RO + chan_base[temp], temp1);

				/* Re-enabling the PRBS checker will reset the word down-counter */
				REG32_SET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], LSI_SP27XX_PRBS56_PCSEL_BM);
			}
			else /* if the PRBS checker is never on, simply read PRBS status register 61 to clear it */
				REG32_READ(LSI_SP27XX_PRBS61_RO + chan_base[temp], temp1);
		}
	}
}

/* "single_channel" must be a single channel; this cannot be a bitmap of multiple channels */
serdesPrbsChkrStat_t sp_SerdesPrbsGetChkrStat(serdesInterface_t interface, uint8_t single_channel)
{
	uint32_t chan_base[4] = {0};
	uint32_t base = 0, num_channels = 0;
	uint64_t temp;
	serdesPrbsChkrStat_t check;

	if (interface == SRIO_SERDES)
	{
		base = LSI_SP27XX_SRIO_SERDES_BASE;
		num_channels = 4;
	}
	else if (interface == GIGE_SERDES)
	{
		base = LSI_SP27XX_GIGE_SERDES_BASE;
		num_channels = 2;
	}
	else if (interface == PCIE_SERDES)
	{
		base = LSI_SP27XX_PCIE_SERDES_BASE;
		num_channels = 2;
	}

	for (temp = 0; temp < num_channels; temp++)
	{
		chan_base[temp] = base + (temp * LSI_SP27XX_SERDES_IVL);
	}

	REG32_READ(LSI_SP27XX_PRBS61_RO + chan_base[single_channel], temp);

	check.pcdone = (temp & LSI_SP27XX_PRBS61_PCDONE_BM) >> LSI_SP27XX_PRBS61_PCDONE_BO;
	check.pcinsync = (temp & LSI_SP27XX_PRBS61_PCINSYNC_BM) >> LSI_SP27XX_PRBS61_PCINSYNC_BO;
	check.pclos = (temp & LSI_SP27XX_PRBS61_PCLOS_BM) >> LSI_SP27XX_PRBS61_PCLOS_BO;
	check.pcerrof = (temp & LSI_SP27XX_PRBS61_PCERROF_BM) >> LSI_SP27XX_PRBS61_PCERROF_BO;
	check.pcworduf = (temp & LSI_SP27XX_PRBS61_PCWORDUF_BM) >> LSI_SP27XX_PRBS61_PCWORDUF_BO;

	/* Enable PRBS checker capture and check PCSEL */
	REG32_SET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[single_channel], LSI_SP27XX_PRBS56_PCCAPTURE_BM);
	check.pcsel = (HW_REG_ACCESS(LSI_SP27XX_PRBS56_RO + chan_base[single_channel]) & LSI_SP27XX_PRBS56_PCSEL_BM) >> LSI_SP27XX_PRBS56_PCSEL_BO;

	/* Read error counter */
	REG32_READ(LSI_SP27XX_PRBS59_RO + chan_base[single_channel], temp);
	check.err_cnt = (temp & LSI_SP27XX_PRBS59_PCERR7_0_BM) >> LSI_SP27XX_PRBS59_PCERR7_0_BO;
	check.err_cnt |= (((HW_REG_ACCESS(LSI_SP27XX_PRBS60_RO + chan_base[single_channel]) & LSI_SP27XX_PRBS60_PCERR23_8_BM) >> LSI_SP27XX_PRBS60_PCERR23_8_BO) << 8);

	/* Read word counter */
	check.word_cnt = (HW_REG_ACCESS(LSI_SP27XX_PRBS57_RO + chan_base[single_channel]) & LSI_SP27XX_PRBS57_PCWORD15_0_BM) >> LSI_SP27XX_PRBS57_PCWORD15_0_BO;
	check.word_cnt |= (((HW_REG_ACCESS(LSI_SP27XX_PRBS58_RO + chan_base[single_channel]) & LSI_SP27XX_PRBS58_PCWORD31_16_BM) >> LSI_SP27XX_PRBS58_PCWORD31_16_BO) << 16);
	check.word_cnt |= (((temp & LSI_SP27XX_PRBS59_PCWORD39_32_BM) >> LSI_SP27XX_PRBS59_PCWORD39_32_BO) << 32);

	/* Disable the PRBS Checker Capture */
	REG32_RESET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[single_channel], LSI_SP27XX_PRBS56_PCCAPTURE_BM);

	return(check);
}

int32_t sp_SerdesPrbsGenCtrl(serdesPrbsCtl_t ctrl, serdesInterface_t interface, uint8_t channel, serdesPrbsPoly_t polynomial, uint8_t ckiInMHz)
{
	uint32_t chan_base[4] = {0};
	uint32_t temp, base = 0, num_channels = 0;

	if (interface == SRIO_SERDES)
	{
		base = LSI_SP27XX_SRIO_SERDES_BASE;
		num_channels = 4;
	}
	else if (interface == GIGE_SERDES)
	{
		base = LSI_SP27XX_GIGE_SERDES_BASE;
		num_channels = 2;
	}
	else if (interface == PCIE_SERDES)
	{
		base = LSI_SP27XX_PCIE_SERDES_BASE;
		num_channels = 2;
	}

	for (temp = 0; temp < num_channels; temp++)
	{
		chan_base[temp] = base + (temp * LSI_SP27XX_SERDES_IVL);

		if ((channel & CHAN(temp)) == CHAN(temp))
		{
			if (ctrl == PRBS_start)
			{
				REG32_RESET_BITS(LSI_SP27XX_PRBS52_RO + chan_base[temp], LSI_SP27XX_PRBS52_PGSEL_BM | LSI_SP27XX_PRBS52_PGPNSEL_BM);
				REG32_SET_BITS(LSI_SP27XX_PRBS52_RO + chan_base[temp], LSI_SP27XX_PRBS52_PGSEL_BM | ((polynomial << LSI_SP27XX_PRBS52_PGPNSEL_BO) & LSI_SP27XX_PRBS52_PGPNSEL_BM));
			}
			else if (ctrl == PRBS_stop)
				REG32_RESET_BITS(LSI_SP27XX_PRBS52_RO + chan_base[temp], LSI_SP27XX_PRBS52_PGSEL_BM);
			else /* invalid ctrl value */
				return(ERROR);
		}
	}

	//if (sp_delayUsingRTC(1000,ckiInMHz) != 0) /* 1 ms is implemented for safety */
	//	return(ERROR);
lsi_mg_delay(0xFFFFF);

	return(SUCCESS);
}

uint64_t sp_SerdesPrbsChkrCtrl(serdesPrbsCtl_t ctrl, serdesInterface_t interface, uint8_t channel, serdesPrbsPoly_t polynomial, run4ever_t run4ever, uint64_t numwords, uint8_t ckiInMHz)
{
	uint32_t chan_base[4] = {0};
	uint32_t x, temp, temp1, base = 0, num_channels = 0;
	uint64_t status = SUCCESS;

	if (interface == SRIO_SERDES)
	{
		base = LSI_SP27XX_SRIO_SERDES_BASE;
		num_channels = 4;
	}
	else if (interface == GIGE_SERDES)
	{
		base = LSI_SP27XX_GIGE_SERDES_BASE;
		num_channels = 2;
	}
	else if (interface == PCIE_SERDES)
	{
		base = LSI_SP27XX_PCIE_SERDES_BASE;
		num_channels = 2;
	}

	for (temp = 0; temp < num_channels; temp++)
	{
		chan_base[temp] = base + (temp * LSI_SP27XX_SERDES_IVL);

		if ((channel & CHAN(temp)) == CHAN(temp))
		{
			if (ctrl == PRBS_start)
			{
				/* It takes some time (up to 1us) for the CDR to lock to the incoming data.  It is recommended
				 * here to assert RX_RELOCK to 1, then clear it back to 0, then wait 1us before enabling the
				 * checker.
				 */
				REG32_SET_BITS(LSI_SP27XX_RXDCORE2_RO + chan_base[temp], LSI_SP27XX_RXDCORE2_RX_RELOCKO_BM | LSI_SP27XX_RXDCORE2_RX_RELOCKF_BM);
				SERDES_RESET_BITS(LSI_SP27XX_RXDCORE2_RO + chan_base[temp], LSI_SP27XX_RXDCORE2_RX_RELOCKO_BM, LSI_SP27XX_RXDCORE2_RX_RELOCKF_BM);

		//		if (sp_delayUsingRTC(1000,ckiInMHz) != 0) /* Should be 1 us, but 1 ms is implemented for safety */
		//			return(ERROR);
lsi_mg_delay(0xFFFFF);

				/* Check if RX_FRQINVLD is set */
				for (x=0; x<10; x++)
					REG32_READ(LSI_SP27XX_RXDCORE11_RO + chan_base[temp], temp1);

				if ((temp1 & LSI_SP27XX_RXDCORE11_RX_FRQINVLD_BM) == LSI_SP27XX_RXDCORE11_RX_FRQINVLD_BM)
				{
					status |= ERR_RX_FRQINVLD_SET_ON_CH(temp);
				}

				/* Set the checker word count */
				REG32_RESET_BITS(LSI_SP27XX_PRBS57_RO + chan_base[temp], LSI_SP27XX_PRBS57_PCWORD15_0_BM);
				REG32_RESET_BITS(LSI_SP27XX_PRBS58_RO + chan_base[temp], LSI_SP27XX_PRBS58_PCWORD31_16_BM);
				REG32_RESET_BITS(LSI_SP27XX_PRBS59_RO + chan_base[temp], LSI_SP27XX_PRBS59_PCWORD39_32_BM);

				REG32_SET_BITS(LSI_SP27XX_PRBS57_RO + chan_base[temp], NWORDS_TO_PRBS57_PCWORD15_0_BM(numwords));
				REG32_SET_BITS(LSI_SP27XX_PRBS58_RO + chan_base[temp], NWORDS_TO_PRBS58_PCWORD31_16_BM(numwords));
				REG32_SET_BITS(LSI_SP27XX_PRBS59_RO + chan_base[temp], NWORDS_TO_PRBS59_PCWORD39_32_BM(numwords));

				/* Configure run4ever */
				REG32_RESET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], LSI_SP27XX_PRBS56_RUN4EVER_BM);
				REG32_SET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], ((run4ever << LSI_SP27XX_PRBS56_RUN4EVER_BO) & LSI_SP27XX_PRBS56_RUN4EVER_BM));

				/* Set the polynomial and enable the checker */
				REG32_RESET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], LSI_SP27XX_PRBS56_PCSEL_BM | LSI_SP27XX_PRBS56_PCPNSEL_BM);
				REG32_SET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], LSI_SP27XX_PRBS56_PCSEL_BM | ((polynomial << LSI_SP27XX_PRBS56_PCPNSEL_BO) & LSI_SP27XX_PRBS56_PCPNSEL_BM));

			}
			else if (ctrl == PRBS_stop)
			{
				REG32_RESET_BITS(LSI_SP27XX_PRBS56_RO + chan_base[temp], LSI_SP27XX_PRBS56_PCSEL_BM);
			}
			else /* invalid ctrl value */
				return(MISC_ERR);
		}
	}

	return(status);
}

int32_t
sp_SerdesPrbsWaitPcDone(serdesRateCfg_t rate, uint64_t numwords, uint8_t ckiInMHz)
{
	uint64_t wait_time, timeoutInCycles;
	uint32_t word_rate = 0;

	/* First we need to check if the RTC is in use */
    if (CHK_REG_MASK(LSI_SP27XX_CAR_RTCCTL_RA, LSI_SP27XX_RTCCTL_RTCEN_BM))
    	return(ERROR); /* RTC is in use */

	if (rate == GBAUD_1_25)
		word_rate = 125; /* words per uS = (1250 bits/uS)/(10 bits/word) */
	else if (rate == GBAUD_2_5)
		word_rate = 250; /* words per uS = (2500 bits/uS)/(10 bits/word) */
	else if (rate == GBAUD_3_125)
		word_rate = 312; /* words per uS = (3125 bits/uS)/(10 bits/word) */
	else if (rate == GBAUD_5_0)
		word_rate = 500; /* words per uS = (5000 bits/uS)/(10 bits/word) */

	/* Calculate the wait time (in uS) required at the checker */
	wait_time = numwords/word_rate;

	/* Due to a 10-bit to 20-bit conversion in the checker, the wait time is doubled */
	wait_time *= 2;

    /* Get the wait time in the form of CKI cycles */
    timeoutInCycles = wait_time * (ckiInMHz + 1);

    /* Divide by 2 for SYSCLK cycles */
    timeoutInCycles = timeoutInCycles >> 1;

    /* Enable RTC */
    REG32_SET_BITS(LSI_SP27XX_CAR_RTCCTL_RA, LSI_SP27XX_RTCCTL_RTCEN_BM);

    /* Multiply count parameter by the PLL multiplier field if PLL is not in bypass mode */
    if (CHK_REG_MASK(LSI_SP27XX_CAR_PLL1CTL_RA, LSI_SP27XX_PLL1CTL_PLL1BYP_BM)) {
    	/* PLL is engaged, multiply by the multiplier value (PLL1F) */
    	timeoutInCycles *= (HW_REG_ACCESS(LSI_SP27XX_CAR_PLL1CTL_RA) & LSI_SP27XX_PLL1CTL_PLL1F_BM) + 2;
    	/* adjust for output divider */
    	timeoutInCycles = timeoutInCycles >> HW_REG_ACCESS(LSI_SP27XX_CAR_PLL1SEL_RA);
    }

    /* Reset RTC */
	REG32_SET_BITS(LSI_SP27XX_CAR_RTCCTL_RA, LSI_SP27XX_RTCCTL_RTCRST_BM);

	while (*(volatile unsigned long long*)LSI_SP27XX_CAR_RTC0_RA < timeoutInCycles);

	/* Disable RTC */
	REG32_RESET_BITS(LSI_SP27XX_CAR_RTCCTL_RA, LSI_SP27XX_RTCCTL_RTCEN_BM);

	return(SUCCESS);
}

/******** History ********
$Log: libserdes.c,v $
Revision 1.2  2017/07/28 07:58:48  harrchan
Collapse Oakenshield-branch to Main Trunk.

Revision 1.1.2.1  2017/06/29 08:14:36  harrchan
Initial commit code for Oakenshield

Revision 1.2  2012/05/10 22:48:11  srane
clean up and modify files for exception handling and TDM tests.

Revision 1.1  2012/04/18 09:47:31  srane
Initial checkin


$Endlog$
*/
